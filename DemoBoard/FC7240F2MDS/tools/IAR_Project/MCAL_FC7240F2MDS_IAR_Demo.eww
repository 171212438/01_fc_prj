<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MCAL_FC7240F2MDS_IAR_Demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
