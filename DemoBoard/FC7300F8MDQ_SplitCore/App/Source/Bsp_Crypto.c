#include "Bsp_Crypto.h"

void Bsp_CryptoMacGenerateTest(void);
void Bsp_CryptoAesTest(void);
void Bsp_CryptoTrngTest(void);
void Bsp_CryptoHashTest(void);
void Bsp_CryptoECC256Test(void);
void Bsp_CryptoRsaPkcs1Test(void);
void Bsp_CryptoRsaSsaPssTest(void);
void Bsp_CryptoRsaSsaPssSubjectPublicInfoTest(void);
void Bsp_CryptoRsaSsaPkcs1v15SubjectPublicInfoTest(void);
void Bsp_CryptoSm2VerifyTest(void);

void Bsp_Crypto_Init(void)
{
    Crypto_Init(NULL_PTR);
}

void Crypto_Mpu_CleanDCache(void)
{
    if (SCB_HWA_DCacheEnabled(FC7XXX_SCB))
    {
        SCB_HWA_CleanDCache(FC7XXX_SCB);
    }
}

void Crypto_Mpu_CleanAndFlushDCache(void)
{
    if (SCB_HWA_DCacheEnabled(FC7XXX_SCB))
    {
        SCB_HWA_CleanInvalidateDCache(FC7XXX_SCB);
    }
}

void Bsp_Crypto_1s_Task_Event(void)
{
#if ((\
	  (DEVICE_SERIES == FC7300F4MDDxxxxT1C)\
	||(DEVICE_SERIES == FC7300F4MDDxxxxT1B)\
	||(DEVICE_SERIES == FC7300F8MDTxxxxT1B)\
	||(DEVICE_SERIES == FC7300F8MDQxxxxT1B))\
	&&(MAX_CORE_NUM > 1u))
    if (0 == Cpm_HWA_GetCoreId())
    {
        Bsp_CryptoRsaPkcs1Test();
        Bsp_CryptoRsaSsaPssTest();
        Bsp_CryptoAesTest();
        Bsp_CryptoTrngTest();
        Bsp_CryptoHashTest();
        Bsp_CryptoMacGenerateTest();
        Bsp_CryptoRsaSsaPssSubjectPublicInfoTest();
        Bsp_CryptoRsaSsaPkcs1v15SubjectPublicInfoTest();
    }
    else if(1 == Cpm_HWA_GetCoreId())
    {
        Bsp_CryptoECC256Test();
        Bsp_CryptoSm2VerifyTest();
    }
    else
    {

    }
#else
    Bsp_CryptoRsaPkcs1Test();
    Bsp_CryptoRsaSsaPssTest();
    Bsp_CryptoAesTest();
    Bsp_CryptoTrngTest();
    Bsp_CryptoHashTest();
    Bsp_CryptoECC256Test();
    Bsp_CryptoMacGenerateTest();
    Bsp_CryptoRsaSsaPssSubjectPublicInfoTest();
    Bsp_CryptoRsaSsaPkcs1v15SubjectPublicInfoTest();
    Bsp_CryptoSm2VerifyTest();
#endif
}

uint8       g_aCmacResult[16];
uint8 g_aCmacInputBuf[16] = { 0xa9, 0x0a, 0x45, 0x9d, 0xa9, 0x9c, 0x6b, 0xf8,
                                    0xe9, 0x5c, 0x7b, 0xad, 0x8b, 0xb0, 0xc9, 0x9f };
uint8 g_aCmacKey[32] = { 0x6e, 0x11, 0x89, 0xd0, 0xf4, 0x0e, 0xff, 0x3e, 0x8f, 0x7d, 0x08,
                               0x7c, 0x69, 0x58, 0x27, 0xd7, 0xba, 0xc9, 0xd1, 0xd9, 0x62, 0x43,
                               0x02, 0xc8, 0x50, 0xc9, 0x62, 0xf5, 0xb9, 0x5d, 0xca, 0x87 };
uint32      g_u32CmacResultBufLen = sizeof(g_aCmacResult);
uint8 ScatterCmacContext[0x400];
uint32 u32ScatterCmacContextLength = sizeof(ScatterCmacContext);
uint8 ScatterCmacOut[16];
uint32 u32ScatterCmacOutLength = sizeof(ScatterCmacOut);

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_CMAC = {
    .resultLength              = 0,
    .service                   = CRYPTO_MACGENERATE,
    .algorithm={
        .family          = CRYPTO_ALGOFAM_AES,
        .secondaryFamily = CRYPTO_ALGOFAM_NOT_SET,
        .keyLength       = 256,
        .mode            = CRYPTO_ALGOMODE_CMAC,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_CMAC = {
    .callbackId                 = 0,
    .primitiveInfo              = &tCryptoPrimitiveInfo_CMAC,
    .secureCounterId            = 0,
    .cryIfKeyId                 = 0,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = FALSE,
};

Crypto_JobType tCryptoJob_CMAC = {
    .jobId                                   = 1,
    .jobState                                = CRYPTO_JOBSTATE_IDLE,
    .jobPrimitiveInputOutput = {
        .mode            = CRYPTO_OPERATIONMODE_SINGLECALL,
        .outputLengthPtr = &g_u32CmacResultBufLen,
        .outputPtr   = &g_aCmacResult[0], /* the result should be:0ae3b761b0759c8c4435705e95f141b3*/
        .inputPtr    = &g_aCmacInputBuf[0],
        .inputLength = sizeof(g_aCmacInputBuf),
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_CMAC,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 6,
};

void        Bsp_CryptoMacGenerateTest(void)
{
    if (E_OK == Crypto_KeyElementSet(tCryptoJob_CMAC.cryptoKeyId,
                                     CRYPTO_KE_MAC_KEY /*elementid*/,
                                     &g_aCmacKey[0],
                                     32)
       )
    {
        if (E_OK == Crypto_KeySetValid(tCryptoJob_CMAC.cryptoKeyId))
        {
            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_START;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SAVE_CONTEXT;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputPtr = &ScatterCmacContext[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterCmacContextLength;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SINGLECALL;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &g_aCmacInputBuf[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = 16;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputPtr = &g_aCmacResult[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputLengthPtr = &g_u32CmacResultBufLen;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_RESTORE_CONTEXT;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &ScatterCmacContext[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = u32ScatterCmacContextLength;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_UPDATE;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &g_aCmacInputBuf[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = 6;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SAVE_CONTEXT;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputPtr = &ScatterCmacContext[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterCmacContextLength;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SINGLECALL;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &g_aCmacInputBuf[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = 16;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputPtr = &g_aCmacResult[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputLengthPtr = &g_u32CmacResultBufLen;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_RESTORE_CONTEXT;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &ScatterCmacContext[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = u32ScatterCmacContextLength;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_UPDATE;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &g_aCmacInputBuf[6];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = 5;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);

            tCryptoJob_CMAC.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_FINISH;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputPtr = &g_aCmacInputBuf[11];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.inputLength = 5;
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputPtr = &ScatterCmacOut[0];
            tCryptoJob_CMAC.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterCmacOutLength;
            Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_CMAC);
            while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_CMAC.jobState);
        }
        else
        {
            ;
        }
    }
}

uint8 aN[512]={
                187,194,70,181,118,68,95,196,222,48,22,59,212,70,237,104,216,25,228,217,198,
                104,194,210,213,130,251,23,167,37,184,183,44,72,75,14,125,167,129,198,94,
                9,213,202,230,13,2,79,139,141,33,97,129,225,26,196,138,89,49,137,40,
                75,38,89,40,86,240,255,64,19,100,130,174,202,87,47,72,95,37,95,193,
                140,65,169,255,233,169,25,153,2,130,219,64,179,87,154,168,140,67,149,238,
                35,135,14,201,214,167,157,95,101,115,199,116,86,180,180,9,153,161,254,135,
                227,20,218,253,9,61,21,157,197,51,250,176,192,187,122,246,250,67,140,183,
                27,16,60,230,102,187,52,36,85,159,115,88,103,218,73,1,52,106,149,24,
                127,38,28,200,51,41,102,92,123,132,220,221,7,234,171,26,214,130,71,241,
                123,14,27,144,40,37,115,8,162,177,82,13,4,51,101,12,57,105,19,235,
                211,92,151,65,171,246,99,244,36,85,78,15,204,86,83,86,229,82,34,132,
                143,165,224,165,89,124,223,249,70,254,241,148,158,21,195,146,156,15,150,249,
                60,51,126,239,72,243,237,99,231,91,78,164,166,87,190,215,84,185,19,203,
                251,242,81,69,249,46,42,221,47,249,211,211,207,127,68,157,234,71,116,113,
                170,227,226,13,121,217,200,188,229,0,37,247,192,120,167,216,47,163,170,214,
                29,53,93,97,61,72,146,14,47,165,8,110,187,2,9,79,107,110,113,33,
                154,209,228,181,82,248,122,17,53,2,163,120,49,26,6,234,209,116,219,85,
                246,14,211,37,254,60,191,164,147,23,2,127,84,14,155,230,215,119,142,143,
                55,229,236,74,71,27,78,63,107,182,158,163,26,18,68,161,161,52,92,239,
                89,193,97,29,84,231,237,199,124,139,59,197,168,41,78,163,73,51,238,155,
                2,115,33,120,37,191,29,158,91,19,239,3,56,254,80,82,203,134,66,97,
                114,36,47,72,9,106,52,7,75,85,117,127,142,24,168,76,49,145,85,9,
                209,41,72,49,164,140,218,103,34,210,142,156,203,167,247,30,80,59,166,251,
                69,182,37,123,21,209,110,89,54,198,149,25,19,70,12,150,9,3,247,177,
                134,147,207,141,150,79,169,53,199,205,133,15,107,128,231,240,188,171,51,131,
                196,52,246,10,196,182,72,13,217,85,243 };

uint8 aRsa4096Pkcs1SignResult[516]={
                        20,23,51,54,48,205,181,192,135,182,202,81,83,169,128,200,8,251,232,89,44,
                        200,68,17,219,114,152,46,82,174,23,227,231,239,199,214,202,115,203,78,120,
                        177,175,91,183,147,2,95,35,179,149,201,227,26,240,48,128,150,44,153,135,
                        12,186,187,178,58,47,98,161,251,171,35,183,144,249,1,35,235,163,20,92,
                        112,239,253,217,241,62,25,43,162,159,135,178,3,211,7,139,143,252,251,68,
                        241,132,45,132,175,86,41,118,125,23,243,94,164,5,10,153,232,154,104,254,
                        148,195,14,235,181,172,233,37,125,209,104,80,34,149,150,211,55,142,247,212,
                        27,44,50,75,139,141,250,118,89,109,215,208,147,157,4,179,249,38,119,24,
                        220,181,255,37,149,197,115,190,119,186,139,113,159,33,0,60,62,165,195,157,
                        74,232,84,193,69,194,6,149,127,66,145,76,138,16,63,126,104,43,175,249,
                        204,127,152,190,133,166,199,125,134,59,201,201,212,109,74,156,112,215,230,246,
                        159,53,155,238,54,153,139,133,184,151,238,74,33,132,151,118,62,89,12,22,
                        108,125,40,75,141,53,230,5,198,178,84,13,145,157,60,152,44,250,158,254,
                        113,9,178,120,82,161,90,173,81,93,26,248,105,20,218,232,80,53,109,72,
                        168,98,137,49,114,197,100,164,180,209,101,232,14,56,185,154,61,38,148,128,
                        146,72,57,184,5,244,22,181,78,147,43,140,143,21,43,129,178,124,30,218,
                        247,92,235,71,86,41,35,61,169,79,172,141,81,208,133,1,206,229,72,141,
                        242,230,72,211,23,68,250,19,114,53,181,141,241,115,157,69,113,242,228,61,
                        249,51,193,215,16,18,103,67,7,115,36,253,74,254,205,119,163,184,43,86,
                        150,30,207,182,79,223,25,11,115,254,97,218,252,137,84,110,117,45,46,1,
                        120,173,248,203,87,40,179,218,221,103,176,203,203,21,73,226,103,37,100,59,
                        28,166,173,165,251,138,173,17,118,179,146,49,203,247,27,200,215,232,149,193,
                        116,67,174,38,218,103,4,41,157,73,49,50,62,185,169,144,182,26,142,164,
                        86,252,231,95,28,113,19,151,49,154,162,180,191,250,205,252,97,222,185,105,
                        31,162,109,148,61,177,98,148,234,226,71,249,49,239,253,21,0,188,108,203,
                        235,41,136,230,222,108,187,124,35,137,22,0,0,0,0 };

uint8 aPublicKey[512]={
                        1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                        0,0,0,0,0,0,0,0,0,0,0 };

uint8 aRsa4096Pkcs1Message[0x400]={
                                    15,182,216,111,247,149,140,131,17,244,33,28,50,143,224,37,51,184,107,102,202,
                                    92,32,88,209,170,38,129,72,163,163,59,152,61,99,86,69,52,176,195,36,
                                    94,33,149,5,190,41,133,64,85,125,187,225,42,38,33,41,7,63,71,172,
                                    65,202,54,78,177,85,251,219,235,55,73,118,184,94,51,159,202,4,141,196,
                                    142,192,33,37,165,138,26,114,123,34,12,80,69,47,229,18,98,18,185,118,
                                    242,70,183,91,112,240,59,170,55,37,225,44,84,138,220,55,21,89,98,196,
                                    251,77,76,248,226,245,5,174,192,255,157,105,124,228,113,71,222,215,96,120,
                                    191,215,183,163,17,240,108,115,202,7,100,115,197,236,228,189,206,218,84,158,
                                    209,17,108,152,160,59,205,14,146,224,167,133,142,145,246,97,184,54,9,165,
                                    131,92,254,246,161,70,185,39,173,9,55,41,229,195,206,59,145,118,121,126,
                                    213,110,227,15,146,176,66,19,16,97,148,191,69,66,226,73,85,49,70,243,
                                    114,65,5,163,78,147,129,7,83,79,20,147,72,179,143,122,245,81,97,217,
                                    28,72,66,174,204,96,15,205,237,151,193,127,121,171,233,199,102,111,15,249,
                                    115,48,14,25,196,181,39,56,240,113,115,5,118,110,204,1,130,126,9,136,
                                    174,169,254,145,250,6,28,214,18,73,227,168,67,234,145,193,79,101,99,75,
                                    94,164,100,114,202,234,40,15,9,17,197,195,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
                                    0,0,0,0,0,0,0,0,0,0,5,0,0,0,0,64,127,1,33,60,
                                    127,1,33,255,255,255,255,240,0,0,10,0,160,6,64,0,0,0,0,0,
                                    160,6,64,0,0,64,0,0,160,6,64,10,0,0,0,0,160,6,64,240,
                                    0,0,1,0,160,6,64,0,0,128,0,0,0,0,0,0,0,0,128,0,
                                    0,0,0,0,0,0,128,64,127,1,0,52,0,0,0,72,127,1,33,160,
                                    127,1,33,152,127,1,33,0,160,6,64,8,0,0,0,148,127,1,33,1,
                                    0,0,0,0,0,1,0,0,0,0,0,0,0,1,0,0,0,1,0,0,
                                    0,0,0,0,0,1,0,4,0,0,0,0,0,192,0,136,127,1,33,136,
                                    127,1,33,0,0,147,78,176,127,1,33,52,0,2,1,1,0,0,0,0,
                                    2,1,1,1,127,1,33,176,127,1,33,0,0,147,78,176,127,1,33,99,
                                    17,0,1,0,0,0,0,5,0,3,0,72,130,88,27,77,180,60,158,0,
                                    0,0,0,0,0,111,77,236,193,235,11,128,3,0,0,62,18,0,0,0,
                                    0,0,0 };

Crypto_VerifyResultType RsaPkcs1VerifyResult = CRYPTO_E_VER_NOT_OK;

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_RSA_PKCS1 = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_RSA,
        .secondaryFamily = CRYPTO_ALGOFAM_SHA2_256,
        .keyLength       = 4096,
        .mode            = CRYPTO_ALGOMODE_RSASSA_PKCS1_v1_5,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_RSA_PKCS1 = {
    .callbackId                 = 1,
    .primitiveInfo              = &tCryptoPrimitiveInfo_RSA_PKCS1,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tCryptoJob_RSA_PKCS1 = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aRsa4096Pkcs1Message[0],
            .inputLength = 313,
            .secondaryInputPtr = &aRsa4096Pkcs1SignResult[0],
            .secondaryInputLength = 512,
            .verifyPtr = &RsaPkcs1VerifyResult,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_RSA_PKCS1,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 14,    // -1 -----> index of  Crypto_CryptoKeyList_PC
};

void Bsp_CryptoRsaPkcs1Test(void)
{
    if (E_OK == Crypto_KeyElementSet(tCryptoJob_RSA_PKCS1.cryptoKeyId,
                                     CRYPTO_KE_CIPHER_RSA_KEY_E /*elementid*/,
                                     &aPublicKey[0],
                                     3)
       )
    {
        if (E_OK == Crypto_KeyElementSet(tCryptoJob_RSA_PKCS1.cryptoKeyId,
                                         CRYPTO_KE_CIPHER_RSA_KEY_N /*elementid*/,
                                         &aN[0],
                                         512)
            )
        {
            if (E_OK == Crypto_KeySetValid(tCryptoJob_RSA_PKCS1.cryptoKeyId))
            {
                if (E_OK == Crypto_ProcessJob(2, (Crypto_JobType *)&tCryptoJob_RSA_PKCS1))
                {
                    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_RSA_PKCS1.jobState);
                }
            }
            else
            {
                ;
            }
        }
    }
}

uint8 aTestDataByteArray_RsaSsaPss[0x400]={
                            0x6E,0x7F,0xB5,0x69,0x2C,0xCF,0xB8,0xEE,0x50,0xCB,0xE6,0xCF,0xC5,0x59,0x6C,0xED,0x78,0xDD,0x85,0xA2,0x50,
                            0x9A,0x3F,0x29,0xA4,0x73,0x8C,0x3E,0xB2,0x81,0x23,0x66,0xC5,0x10,0x71,0x11,0x13,0x5D,0xE7,0xE2,0xA3,
                            0xD7,0x42,0x25,0xB4,0x9C,0x85,0xF,0xDA,0xE9,0x95,0xC8,0x4E,0x10,0xFE,0xAF,0xB5,0x8F,0xDF,0xED,0x76,
                            0xF0,0x38,0x71,0x82,0xF,0x77,0xC6,0xB0,0x87,0x73,0x65,0xF7,0xF5,0x92,0xEA,0xA3,0x6A,0x1D,0xB9,0x9A,
                            0x7A,0x9C,0xA4,0x83,0x52,0xD6,0xC7,0x71,0x79,0x1B,0xF0,0x17,0x6A,0x98,0xE3,0x81,0x85,0x3F,0xCC,0x12,
                            0xC,0xB8,0xAC,0xBF,0x8B,0xC6,0xA0,0x72,0x45,0x62,0x26,0x87,0x12,0xA6,0x8F,0xFA,0x81,0x27,0x65,0x41,
                            0x16,0x74,0x72,0x0,0x42,0x80,0xEB,0x7F,0x29,0x3B,0x22,0x5C,0x4D,0x4A,0x68,0xF9,0x3E,0x36,0x32,0x83,
                            0xED,0x62,0xDF,0x37,0x15,0xB3,0x41,0xE4,0x9F,0x8D,0x5C,0xF6,0x66,0xF4,0xC1,0xDB,0x0,0xA3,0xC4,0x46,
                            0x5B,0xE1,0xB4,0x85,0xF3,0x8D,0x65,0x10,0x32,0x4F,0x9C,0xC,0xEE,0x1,0x3B,0x19,0x4,0xC4,0x38,0xC,
                            0x2E,0x86,0x97,0x46,0x2A,0x17,0xD9,0x79,0xE3,0xB3,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x5,0x0,0x0,0x0,0x0,0x40,0x7F,0x1,0x21,0x3C,
                            0x7F,0x1,0x21,0xFF,0xFF,0xFF,0xFF,0xF0,0x0,0x0,0xA,0x0,0xA0,0x6,0x40,0x0,0x0,0x0,0x0,0x0,
                            0xA0,0x6,0x40,0x0,0x0,0x40,0x0,0x0,0xA0,0x6,0x40,0xA,0x0,0x0,0x0,0x0,0xA0,0x6,0x40,0xF0,
                            0x0,0x0,0x1,0x0,0xA0,0x6,0x40,0x0,0x0,0x80,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x80,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x0,0x80,0x40,0x7F,0x1,0x0,0x34,0x0,0x0,0x0,0x48,0x7F,0x1,0x21,0xA0,
                            0x7F,0x1,0x21,0x98,0x7F,0x1,0x21,0x0,0xA0,0x6,0x40,0x8,0x0,0x0,0x0,0x94,0x7F,0x1,0x21,0x1,
                            0x0,0x0,0x0,0x0,0x0,0x1,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x1,0x0,0x0,0x0,0x1,0x0,0x0,
                            0x0,0x0,0x0,0x0,0x0,0x1,0x0,0x4,0x0,0x0,0x0,0x0,0x0,0xC0,0x0,0x88,0x7F,0x1,0x21,0x88,
                            0x7F,0x1,0x21,0x0,0x0,0x93,0x4E,0xB0,0x7F,0x1,0x21,0x34,0x0,0x2,0x1,0x1,0x0,0x0,0x0,0x0,
                            0x2,0x1,0x1,0x1,0x7F,0x1,0x21,0xB0,0x7F,0x1,0x21,0x0,0x0,0x93,0x4E,0xB0,0x7F,0x1,0x21,0x63,
                            0x11,0x0,0x1,0x0,0x0,0x0,0x0,0x5,0x0,0x3,0x1,0x48,0x82,0x58,0x1B,0x4D,0xB4,0x3C,0x9E,0xBB,
                            0x81,0x13,0x66,0x0,0x0,0x6F,0x4D,0xEC,0xC1,0xEB,0xB,0x80,0x3,0x0,0x0,0x35,0x12,0x0,0x0,0x0,
                            0x0,0x0,0x0 };

uint8 aSignResult_RsaSsaPss[516]={
                    0x93,0x61,0x5,0x43,0x4,0xF0,0x59,0xD4,0x53,0xE4,0x2F,0xDB,0xBD,0x8B,0x6C,0x63,0x3,0xED,0xE4,0x5,0xC4,
                    0x84,0x80,0xD6,0x45,0xDE,0xF4,0x25,0x65,0x8E,0x33,0x51,0xEE,0x28,0xD1,0x63,0xA8,0x9E,0x87,0x89,0xB4,
                    0xAA,0xF2,0xAB,0x46,0x86,0xF8,0x9C,0x2C,0x50,0xF5,0xAA,0x3,0x2E,0x66,0x19,0x1E,0x7C,0x51,0x69,0x90,
                    0x7C,0x48,0xCA,0xA3,0xAE,0xFD,0xD6,0xDA,0x65,0x88,0x26,0xAB,0x3A,0xF2,0xDD,0xAC,0x60,0xB8,0x68,0x58,
                    0x4,0xAA,0x2D,0x8A,0xE,0x3F,0x64,0x76,0x22,0x80,0xC0,0x19,0xDB,0xF3,0x6E,0xEF,0x1A,0x32,0x8,0xB3,
                    0x3A,0x9,0x92,0xD0,0x0,0x72,0x8,0x56,0x34,0x53,0x93,0x5D,0xDA,0x32,0x19,0x84,0xDB,0x49,0x34,0x51,
                    0x7E,0x96,0xD2,0xC6,0xD6,0xA,0xD6,0x11,0xF1,0x80,0xEF,0xB7,0x63,0xC,0x22,0x39,0xAB,0xB,0x9D,0x50,
                    0x82,0x11,0x61,0x50,0xDC,0xEE,0x32,0x4F,0xFE,0xED,0xA7,0xBB,0x73,0x6E,0xE,0xEF,0x49,0x6,0xA2,0x39,
                    0xE2,0x88,0xCF,0xE0,0x79,0xF9,0x68,0x97,0xB2,0x86,0xF7,0x6F,0x36,0x6C,0x4C,0x50,0xBA,0x91,0x66,0x9A,
                    0x79,0x30,0xE7,0xE2,0x77,0xE,0xFE,0x4F,0x53,0x3A,0xC2,0x16,0xF0,0xC0,0x28,0xD7,0xF4,0x2C,0x25,0x94,
                    0x3C,0xEB,0xDD,0xEB,0x72,0xEC,0xAC,0xC0,0x6,0x9F,0xB,0x38,0xAE,0x19,0xC8,0x5E,0x7E,0xE3,0x20,0x4B,
                    0x6C,0x91,0x2B,0x32,0xD5,0xC0,0xE6,0x4A,0xD5,0x44,0x31,0x88,0xCE,0x5D,0x91,0x33,0x6C,0x6B,0xBE,0xD3,
                    0x73,0xFB,0x50,0xE8,0x93,0xB7,0xD5,0xEE,0xF0,0xA7,0x1F,0xB6,0x28,0x30,0x87,0xD7,0x6E,0xE8,0x5C,0x49,
                    0x80,0xEC,0x76,0x11,0xD0,0x55,0xB3,0x82,0xBD,0x61,0xDE,0x46,0x85,0xEB,0xCC,0x93,0xCA,0x9D,0xE4,0xC0,
                    0x8A,0x3C,0xE8,0x7E,0xE2,0x2E,0xD2,0x5B,0x21,0xE1,0xA0,0x9,0xB9,0xB8,0x2,0x5E,0xE2,0xCC,0xAD,0xD4,
                    0xA5,0x33,0xD7,0xEB,0xC0,0x98,0x3C,0xAE,0x68,0x4E,0x52,0xBA,0x11,0x46,0xB6,0xFF,0xCE,0x9D,0x8D,0x76,
                    0x1D,0x9A,0x41,0xA5,0x15,0x9D,0x1,0x3D,0xF8,0x76,0x51,0xC5,0xAD,0x4,0xEB,0x41,0xE7,0x90,0x29,0x32,
                    0x17,0x68,0x62,0x47,0x97,0xE2,0xEF,0x3C,0x5F,0x37,0x59,0x78,0x31,0x8C,0xAE,0x27,0xCA,0xCA,0xE4,0x48,
                    0xB1,0x3F,0xE1,0x72,0x23,0x74,0x74,0xB2,0x5C,0xBC,0x4,0xCF,0x58,0x25,0x5A,0xCF,0x1E,0x3,0xCD,0x6E,
                    0xF3,0x9,0x19,0xF8,0x7A,0x0,0x22,0xB6,0x6,0x41,0xCB,0xA,0x1D,0x2F,0x92,0xA4,0xF6,0xCA,0xA5,0x31,
                    0xA9,0xB,0xD0,0xD4,0xCB,0x95,0x80,0xCF,0xD3,0xD4,0x7F,0xD6,0x6B,0x5D,0xF2,0x69,0x78,0x12,0x99,0x44,
                    0x9A,0x95,0xD,0xFD,0x78,0xAD,0x30,0xE2,0x0,0x75,0x29,0x27,0x32,0x5B,0x36,0x68,0xE2,0x5D,0x1B,0xBF,
                    0x23,0xCA,0xBE,0x7F,0xD1,0x3B,0xE8,0x67,0x73,0x60,0xB0,0xD4,0xE8,0xCA,0xBB,0xE0,0x62,0x72,0x70,0xF5,
                    0xD2,0x22,0x90,0xE0,0xAD,0xF7,0x7E,0xAE,0x2,0x92,0xDB,0x42,0xB7,0x14,0xA3,0x2F,0xB4,0xA8,0x42,0xF3,
                    0x64,0x65,0x2C,0x8B,0xB0,0xC5,0x8A,0x1A,0xEA,0xA6,0x30,0x35,0xFA,0x1A,0x47,0x88,0xE0,0xD3,0x72,0x15,
                    0xC,0xDF,0xF0,0x2A,0xFE,0xED,0x44,0x98,0x49,0x71,0x2D,0x0,0x0,0x0,0x0 };

uint8 aPublicKey_RsaSsaPss[512]={
                        0x1,0x0,0x1,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,
                        0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0,0x0 };


uint8 aN_RsaSsaPss[512]={
                0xB8,0xCC,0xAF,0xB,0x12,0x54,0xF5,0x11,0xB4,0xB7,0xEE,0xCC,0xD5,0x7A,0x5A,0xA1,0xF8,0xF7,0x2F,0xE2,0xED,
                0x11,0x7D,0x37,0x14,0x48,0xC5,0xB5,0x87,0x7,0xC4,0xE9,0x5F,0x25,0xEC,0xEF,0x16,0xB3,0xD7,0xFA,0xB7,
                0x59,0x3A,0x8D,0x37,0x61,0x1C,0x52,0x88,0x75,0xF8,0xF7,0xB1,0xA3,0x8B,0x7F,0x1E,0x76,0x43,0x8B,0x70,
                0x46,0x8,0xF1,0x1B,0x8,0xF3,0x6A,0xC1,0x70,0xCA,0x31,0x62,0xDD,0x1F,0x1,0x81,0xB2,0x71,0x65,0x98,
                0x79,0xA9,0x61,0x1C,0x54,0x3E,0xA9,0x79,0xD0,0xC2,0xF1,0x2A,0xB2,0xDE,0x36,0xBA,0xF9,0x6A,0xB9,0x1C,
                0x80,0xEB,0x1D,0x80,0x58,0xB8,0x9D,0x68,0xE8,0x59,0xAC,0x6D,0x1B,0x8,0xAF,0xC2,0x61,0x8F,0xE6,0x52,
                0xD4,0x80,0xEB,0x9B,0xF9,0x41,0x4E,0xD9,0x12,0x39,0x8E,0x25,0xFB,0x2E,0x1A,0x14,0xD6,0xCC,0x99,0xF9,
                0xCC,0x79,0x84,0x7,0x4B,0x13,0x68,0x47,0x45,0x54,0x3C,0x1C,0xA7,0x71,0xF7,0x10,0xD7,0x4A,0x9B,0x34,
                0x44,0x1C,0x6A,0x7C,0x6,0xD0,0x62,0x86,0x6F,0x9C,0x9D,0x1,0x97,0x13,0xCB,0xC4,0x74,0xEF,0xEF,0xA9,
                0xCF,0x11,0x4C,0xFA,0x59,0x6,0xFF,0x88,0x57,0x7C,0x8E,0x77,0x32,0xA1,0x78,0x67,0x1B,0x1,0x6B,0x69,
                0x2B,0x5C,0xFD,0x78,0xC4,0x89,0x52,0x8E,0xD0,0x65,0x27,0x59,0x3,0x51,0x7E,0x58,0x3D,0xD0,0xA5,0x40,
                0x65,0xC6,0x68,0xC3,0x95,0x4C,0xE7,0xB5,0xEF,0x87,0x4E,0xF7,0xE4,0x23,0x96,0xB8,0x5F,0x6C,0x2C,0x91,
                0x0,0x96,0x78,0x7A,0xAE,0x26,0x14,0xCE,0x4B,0x39,0xF2,0xEB,0xDB,0xCB,0xC6,0x7,0xB9,0x72,0xF3,0xED,
                0xA9,0xDD,0x50,0x91,0x78,0xDF,0x27,0x7A,0x16,0x1C,0xF8,0x12,0xEA,0x6F,0x3E,0x3D,0xBF,0x24,0xCC,0x7C,
                0x14,0x48,0x3C,0xB7,0xC5,0x13,0x4F,0x66,0x1F,0x99,0x8C,0x90,0x92,0xF3,0x71,0x40,0x4E,0x99,0xAA,0x6,
                0x16,0xC3,0x26,0x20,0x64,0x18,0x81,0xEE,0xF2,0xAF,0x20,0x37,0xAE,0xDC,0x48,0xF2,0x5C,0xD,0x62,0xEB,
                0x5A,0x6B,0xC3,0xE8,0x99,0x7,0xAD,0xEB,0xE6,0xFD,0x70,0x7A,0xC3,0x5,0xA,0xB3,0xB0,0x8D,0x6D,0x57,
                0xB0,0xB0,0xF3,0x84,0xB8,0xCE,0xB4,0x9B,0xC1,0x3C,0xA,0x7C,0xF7,0x35,0x4C,0x7C,0xA8,0xB3,0xFB,0xA8,
                0x72,0x4B,0xA7,0x6C,0x5B,0x94,0x32,0x75,0x26,0x22,0x6A,0x8A,0x59,0x9A,0xDE,0x98,0xE5,0xCC,0x53,0x44,
                0x2B,0xB3,0x30,0x54,0xA1,0x62,0xE5,0x93,0xBC,0xDF,0xF,0xD1,0xDA,0x6F,0x9C,0x18,0xBC,0x3D,0x84,0x72,
                0x58,0xB7,0xBD,0xA1,0x8E,0x6A,0x59,0x48,0xD3,0x91,0xCA,0xFA,0x24,0x1D,0xC7,0x62,0xD,0xC5,0x90,0xCD,
                0x7A,0xAD,0xC7,0x10,0xCC,0x82,0xF1,0x1D,0x2,0x67,0x91,0x63,0x9B,0x20,0x93,0xBB,0xA8,0x13,0x19,0x22,
                0x3E,0x2D,0x9E,0x40,0xE,0x3,0x4D,0x2D,0xC7,0x8E,0x1C,0x97,0x87,0xCB,0xAA,0x95,0xC1,0x8,0x30,0x51,
                0x5F,0x4C,0x3F,0x5B,0xAD,0x9E,0x20,0xED,0x19,0xE8,0x42,0xF5,0xA1,0x3E,0x43,0x23,0xA1,0x90,0x5B,0x52,
                0xB8,0xF0,0x76,0xD8,0x6F,0x6,0x35,0x63,0x13,0x19,0xA1,0xD5,0x6C,0xCA,0xD3,0xC1,0xCE,0x66,0x4E,0x57,
                0x16,0x6,0x2D,0x15,0x2,0x41,0xD6,0xBB,0xA3,0xFE,0x5F };

Crypto_VerifyResultType VerifyResult_RsaSsaPss = CRYPTO_E_VER_NOT_OK;


Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_RsaSsaPss = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_RSA,
        .secondaryFamily = CRYPTO_ALGOFAM_SHA2_256,
        .keyLength       = 4096,
        .mode            = CRYPTO_ALGOMODE_RSASSA_PSS,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_RsaSsaPss = {
    .callbackId                 = 1,
    .primitiveInfo              = &tCryptoPrimitiveInfo_RsaSsaPss,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tCryptoJob_RsaSsaPss = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aTestDataByteArray_RsaSsaPss[0],
            .inputLength = 191,
            .secondaryInputPtr = &aSignResult_RsaSsaPss[0],
            .secondaryInputLength = 512,
            .verifyPtr = &VerifyResult_RsaSsaPss,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_RsaSsaPss,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 14,    // -1 -----> index of  Crypto_CryptoKeyList_PC
};

void Bsp_CryptoRsaSsaPssTest(void)
{
    if (E_OK == Crypto_KeyElementSet(tCryptoJob_RsaSsaPss.cryptoKeyId,
                                     CRYPTO_KE_CIPHER_RSA_KEY_E /*elementid*/,
                                     &aPublicKey_RsaSsaPss[0],
                                     3)
       )
    {
        if (E_OK == Crypto_KeyElementSet(tCryptoJob_RsaSsaPss.cryptoKeyId,
                                         CRYPTO_KE_CIPHER_RSA_KEY_N /*elementid*/,
                                         &aN_RsaSsaPss[0],
                                         512)
            )
        {
            if (E_OK == Crypto_KeySetValid(tCryptoJob_RsaSsaPss.cryptoKeyId))
            {
                if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_RsaSsaPss))
                {
                    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_RsaSsaPss.jobState);
                }
            }
            else
            {
                ;
            }
        }
    }
}

const uint8 g_aPalinText[] = {0x2, 0x88, 0xa2, 0x9b, 0x7f, 0xc5, 0x66, 0x8, 0x4a, 0xf9, 0x67, 0x68, 0x1c, 0x42, 0x26, 0x1e};

const uint8 g_aAes256Key[] = { 0x33, 0x33, 0x45, 0x67, 0x11, 0x11, 0x22, 0x22, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0,
                               0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78};

const uint8 g_aIv[] = { 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78,
                        0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78};

uint8  g_aResultBuf[16]; //The expected result shoule be 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78
uint32 g_u32ResultBufLen;

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_AES = {
    .resultLength              = 0,
    .service                   = CRYPTO_ENCRYPT,
    .algorithm = {
        .family          = CRYPTO_ALGOFAM_AES,
        .secondaryFamily = CRYPTO_ALGOFAM_NOT_SET,
        .keyLength       = 256,
        .mode            = CRYPTO_ALGOMODE_CBC,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_AES = {
    .callbackId                 = 1,
    .primitiveInfo              = &tCryptoPrimitiveInfo_AES,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tCryptoJob_AES = {
    .jobId    = 1,
    .jobState = CRYPTO_JOBSTATE_IDLE,
    .jobPrimitiveInputOutput = {
        .mode = CRYPTO_OPERATIONMODE_SINGLECALL,
        .outputLengthPtr = &g_u32ResultBufLen,
        .outputPtr       = &g_aResultBuf[0],
        .inputLength = sizeof(g_aPalinText),
        .inputPtr    = &g_aPalinText[0],

    },
    .jobPrimitiveInfo = &tCryptoJobPrimitiveInfo_AES,
    .jobPriority = 0,
    .cryptoKeyId = 3,
};

void Bsp_CryptoAesTest(void)
{

    g_u32ResultBufLen = sizeof(g_aResultBuf);

    if (E_OK == Crypto_KeyElementSet(tCryptoJob_AES.cryptoKeyId,
                                     CRYPTO_KE_CIPHER_KEY,
                                     &g_aAes256Key[0],
                                     sizeof(g_aAes256Key)))
    {
        if (E_OK == Crypto_KeyElementSet(tCryptoJob_AES.cryptoKeyId,
                                         CRYPTO_KE_CIPHER_IV ,
                                         &g_aIv[0],
                                         sizeof(g_aIv)))
        {
            if (E_OK == Crypto_KeySetValid(tCryptoJob_AES.cryptoKeyId))
            {
                if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_AES))
                {
                    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_AES.jobState);
                }
            }
            else
            {
                ;
            }
        }
    }
}

uint8 u8aTgngResultBuffer[16];
uint32 u8TrngResultBufLen = sizeof(u8aTgngResultBuffer);

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_TRNG = {
    .resultLength              = 0,
    .service                   = CRYPTO_RANDOMGENERATE,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_RNG,
        .secondaryFamily = CRYPTO_ALGOFAM_NOT_SET,
        .keyLength       = 0,
        .mode            = CRYPTO_ALGOMODE_TRUE_RNG,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_TRNG = {
    .callbackId                 = 0,
    .primitiveInfo              = &tCryptoPrimitiveInfo_TRNG,
    .secureCounterId            = 0,
    .cryIfKeyId                 = 0,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = FALSE,
};

volatile Crypto_JobType tCryptoJob_TRNG = {
    .jobId    = 1,
    .jobState = CRYPTO_JOBSTATE_IDLE,
    .jobPrimitiveInputOutput = {
        .mode = CRYPTO_OPERATIONMODE_SINGLECALL,
        .outputLengthPtr = &u8TrngResultBufLen,
        .outputPtr       = &u8aTgngResultBuffer[0],
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_TRNG,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 0,
};

void Bsp_CryptoTrngTest(void)
{

    if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_TRNG))
    {
        while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_TRNG.jobState);
    }
}

uint8 u8bigData[16]={0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78};
uint8 HashData[32];
uint32 u32ShaOutputDatalen = sizeof(HashData);

uint8 ScatterHashOut[32];
uint32 u32ScatterHashOutLength = sizeof(ScatterHashOut);
uint8 ScatterHashContext[0x400];
uint32 u32ScatterHashContextLength = sizeof(ScatterHashContext);
Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_HASH = {
    .resultLength              = 0,
    .service                   = CRYPTO_HASH,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_SHA2_256,
        .secondaryFamily = CRYPTO_ALGOFAM_NOT_SET,
        .keyLength       = 0,
        .mode            = CRYPTO_ALGOMODE_NOT_SET,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_HASH = {
    .callbackId                 = 0,
    .primitiveInfo              = &tCryptoPrimitiveInfo_HASH,
    .secureCounterId            = 0,
    .cryIfKeyId                 = 0,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = FALSE,
};

volatile Crypto_JobType tCryptoJob_HASH = {
    .jobId    = 1,
    .jobState = CRYPTO_JOBSTATE_IDLE,
    .jobPrimitiveInputOutput = {
            .inputPtr = &u8bigData[0],
            .inputLength = 16,
            .outputPtr = &HashData[0],
            .outputLengthPtr = &u32ShaOutputDatalen,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_HASH,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 0,
};

void Bsp_CryptoHashTest(void)
{
    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_START;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SAVE_CONTEXT;
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputPtr = &ScatterHashContext[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterHashContextLength;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SINGLECALL;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &u8bigData[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = 16;
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputPtr = &HashData[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputLengthPtr = &u32ShaOutputDatalen;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);
    //The expected result should be 0xdd, 0xcb, 0xc4, 0x5e, 0xd5, 0x38, 0x34, 0x49, 0x0, 0x4f, 0xe6, 0x44, 0xde, 0xc9, 0x38, 0x27, 0xba, 0xf9, 0x4a, 0x56, 0x32, 0x2c, 0xac, 0xe8, 0xd8, 0x13, 0x9e, 0x4, 0x57, 0x2c, 0xa0, 0x1e

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_RESTORE_CONTEXT;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &ScatterHashContext[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = u32ScatterHashContextLength;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_UPDATE;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &u8bigData[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = 6;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SAVE_CONTEXT;
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputPtr = &ScatterHashContext[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterHashContextLength;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_SINGLECALL;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &u8bigData[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = 16;
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputPtr = &HashData[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputLengthPtr = &u32ShaOutputDatalen;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_RESTORE_CONTEXT;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &ScatterHashContext[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = u32ScatterHashContextLength;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_UPDATE;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &u8bigData[6];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = 5;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);

    tCryptoJob_HASH.jobPrimitiveInputOutput.mode = CRYPTO_OPERATIONMODE_FINISH;
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputPtr = &u8bigData[11];
    tCryptoJob_HASH.jobPrimitiveInputOutput.inputLength = 5;
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputPtr = &ScatterHashOut[0];
    tCryptoJob_HASH.jobPrimitiveInputOutput.outputLengthPtr = &u32ScatterHashOutLength;
    Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_HASH);
    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_HASH.jobState);
}

uint8 aECC256_PublicKeyXY[64]={
        0xa4, 0x24, 0x20, 0x98, 0x63, 0x42, 0x66, 0x66, 0x13, 0x78, 0x80, 0x43, 0x38, 0x2b, 0x6b, 0x97,
        0x8b, 0xfb, 0x71, 0x85, 0xff, 0x8d, 0x91, 0xab, 0x5e, 0xdd, 0x8a, 0x5a, 0xef, 0x67, 0x76, 0x75,
        0x26, 0xbf, 0x8b, 0x74, 0x50, 0xb, 0x3e, 0x5a, 0xb8, 0x7a, 0x2d, 0x2c, 0xd1, 0x4f, 0x8a, 0x2e,
        0x64, 0x76, 0xbb, 0x1e, 0x71, 0xde, 0xa3, 0x34, 0xf5, 0xe4, 0x11, 0x15, 0x9f, 0x58, 0x86, 0x31, };
uint8 aECC256_SignatureRS[64]={
        0x16, 0x6, 0xce, 0x3a, 0x78, 0xf2, 0xfb, 0x1d, 0x46, 0x14, 0xad, 0x14, 0x39, 0xe9, 0x3c, 0x73,
        0x24, 0x36, 0xbc, 0x86, 0xc, 0xf7, 0xd7, 0xf7, 0xad, 0x45, 0x80, 0x3e, 0x61, 0x91, 0x56, 0x4,
        0xc1, 0xd9, 0xb5, 0x58, 0x6c, 0x1d, 0x10, 0x58, 0x4f, 0x4d, 0x71, 0x96, 0xb8, 0x95, 0xbd, 0xc4,
        0x45, 0x67, 0x89, 0x6e, 0xb9, 0xb6, 0x4b, 0xcb, 0xcd, 0x86, 0xfd, 0xd2, 0xfd, 0xc9, 0x43, 0x83, };
uint8 aECC256_CurveOID[8]={0x2A, 0x86, 0x48, 0xCE, 0x3D, 0x03, 0x01, 0x07};
uint8 aECC256_Raw_Messege[16]={0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78, 0x12, 0x34, 0x56, 0x78};

Crypto_VerifyResultType VerifyResult_ECC256 = CRYPTO_E_VER_NOT_OK;

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_ECC256 = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_ECCNIST,
        .secondaryFamily = CRYPTO_ALGOFAM_SHA2_256,
        .keyLength       = 256,
        .mode            = CRYPTO_ALGOMODE_NOT_SET,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_ECC256 = {
    .callbackId                 = 1,
    .primitiveInfo              = &tCryptoPrimitiveInfo_ECC256,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tCryptoJob_ECC256 = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aECC256_Raw_Messege[0],
            .inputLength = 16,
            .secondaryInputPtr = &aECC256_SignatureRS[0],
            .secondaryInputLength = 64,
            .verifyPtr = &VerifyResult_ECC256,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_ECC256,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 8,    // -4 -----> index of  Crypto_CryptoKeyList_PC
};

void Bsp_CryptoECC256Test(void)
{
    if (E_OK == Crypto_KeyElementSet(tCryptoJob_ECC256.cryptoKeyId,
                                     CRYPTO_KE_SIGNATURE_KEY /*elementid*/,
                                     &aECC256_PublicKeyXY[0],
                                     64)
       )
    {
        if (E_OK == Crypto_KeyElementSet(tCryptoJob_ECC256.cryptoKeyId,
                                         CRYPTO_KE_SIGNATURE_CURVETYPE /*elementid*/,
                                         &aECC256_CurveOID[0],
                                         8)
            )
        {
            if (E_OK == Crypto_KeySetValid(tCryptoJob_ECC256.cryptoKeyId))
            {
                if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_ECC256))
                {
                    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_ECC256.jobState);
                }
            }
            else
            {
                ;
            }
        }
    }
}

uint8 aBspCrypto_5bytes_PlainText[]={0x12, 0x34, 0x56, 0x78, 0x90};

uint8 aBspCrypto_RsaSsaPss_4096_Signature[]={
0x6f, 0x9e, 0x5c, 0xfa, 0x7a, 0xb0, 0x1b, 0x7a, 0xc9, 0xda, 0xb1, 0xb3, 0x7a, 0x75, 0x73, 0xa1,
0x16, 0xfe, 0x21, 0xf9, 0x26, 0xeb, 0xa, 0x38, 0xf6, 0xab, 0x94, 0xc1, 0xed, 0xc7, 0x79, 0x70,
0x31, 0xeb, 0x45, 0x6e, 0x1d, 0xea, 0xdd, 0xd7, 0x39, 0x87, 0x5f, 0x38, 0x95, 0x8e, 0xd, 0x74,
0x91, 0x82, 0x2a, 0xff, 0xba, 0x64, 0x6e, 0x66, 0xee, 0x5a, 0x6b, 0x17, 0x49, 0xd5, 0x5b, 0x49,
0x7e, 0xe2, 0xd8, 0xb, 0xa6, 0xd4, 0xb1, 0x13, 0x34, 0x91, 0x7a, 0xc5, 0x2d, 0x82, 0x81, 0x4f,
0xae, 0xf0, 0x7d, 0xd3, 0x63, 0x2a, 0xc, 0xc2, 0xa0, 0xc, 0x1b, 0x6, 0xc5, 0x5d, 0x92, 0xf0,
0x17, 0x1d, 0x75, 0x83, 0xdc, 0x8a, 0xc9, 0x80, 0xa3, 0xfe, 0x91, 0x2f, 0x6, 0x5d, 0xe, 0xe,
0x67, 0xaf, 0x59, 0x7f, 0x9, 0x71, 0x4d, 0x1c, 0x8c, 0x80, 0x80, 0x3e, 0xd, 0xe, 0x2b, 0xa1,
0xde, 0x67, 0x63, 0xce, 0xc5, 0x22, 0xba, 0xe9, 0x79, 0xe9, 0xd3, 0x54, 0xb7, 0xa8, 0x3d, 0xb3,
0x25, 0x6f, 0x19, 0xa0, 0x3c, 0xef, 0x23, 0x58, 0x1, 0x1f, 0xf2, 0xf6, 0xbc, 0xe4, 0x16, 0x88,
0x1, 0x53, 0xec, 0x45, 0x47, 0x9f, 0xa7, 0xf8, 0xb2, 0xf7, 0x50, 0xb5, 0x4c, 0x6f, 0x50, 0xe8,
0xba, 0x6a, 0x29, 0xff, 0xc3, 0x6, 0x2a, 0x79, 0x95, 0x22, 0xe2, 0x28, 0x74, 0x1c, 0x1f, 0x13,
0x67, 0xf0, 0xc, 0x4c, 0xd2, 0xd5, 0x96, 0x32, 0x38, 0x8e, 0x62, 0xbb, 0x59, 0xf, 0x77, 0x1d,
0x40, 0x7d, 0xa8, 0xe1, 0xb5, 0xf1, 0xea, 0x24, 0xba, 0x50, 0x5c, 0x77, 0x35, 0xdb, 0xa2, 0xb6,
0x6a, 0xcb, 0x55, 0xfb, 0xc9, 0x79, 0xe7, 0x42, 0xbd, 0xee, 0xb7, 0xdb, 0x6b, 0xe2, 0x2b, 0xc,
0xe5, 0xa3, 0x64, 0xcf, 0xa6, 0x54, 0x8, 0xcb, 0xa, 0x2a, 0x8a, 0x1b, 0x15, 0x6a, 0xda, 0x49,
0xb4, 0x4, 0xe8, 0xc, 0x1e, 0x1b, 0x7c, 0x6c, 0x2a, 0x7e, 0x94, 0x6f, 0x23, 0x8c, 0x38, 0x20,
0xf4, 0xa5, 0xbf, 0x33, 0xfa, 0x31, 0x52, 0x7, 0x9b, 0xce, 0x4a, 0x30, 0x64, 0x2, 0x1d, 0x99,
0x39, 0x16, 0xbb, 0x14, 0x21, 0x25, 0x35, 0x3b, 0x73, 0x5, 0xfe, 0x66, 0x96, 0xe3, 0xde, 0x2f,
0xd, 0x7d, 0x68, 0x36, 0x79, 0xeb, 0xa5, 0x8c, 0x43, 0x3f, 0x3, 0x39, 0x65, 0xb, 0x16, 0xb4,
0x7c, 0x61, 0xac, 0xc4, 0x7, 0x9e, 0xf2, 0x2a, 0x78, 0x47, 0x4c, 0xc8, 0x4a, 0xe9, 0x50, 0xc9,
0x7c, 0x65, 0x27, 0xd0, 0x21, 0x46, 0x76, 0xf5, 0xb7, 0x95, 0x53, 0x54, 0x8b, 0x61, 0x53, 0x17,
0xce, 0x20, 0x71, 0xbc, 0xb1, 0x52, 0x5f, 0x17, 0x5d, 0x1a, 0x68, 0x7f, 0xeb, 0x53, 0x2, 0x1c,
0xe8, 0xeb, 0x63, 0xe5, 0xa9, 0xff, 0xd2, 0xf0, 0x2b, 0xae, 0xb3, 0x48, 0x6a, 0x58, 0xb7, 0xda,
0x8b, 0x4, 0xce, 0x65, 0x2c, 0x4, 0x45, 0xdc, 0xdb, 0xc1, 0x5, 0x16, 0x2f, 0x9c, 0x53, 0x32,
0xf5, 0xee, 0xb9, 0xf0, 0x3a, 0x6b, 0xb2, 0x5a, 0x9e, 0xc2, 0x77, 0x67, 0x4f, 0x92, 0x49, 0x89,
0x4e, 0x4f, 0xac, 0xdb, 0x1b, 0xfc, 0x6f, 0xa3, 0x3a, 0xa9, 0x9d, 0xf5, 0x21, 0x21, 0x87, 0x9d,
0x75, 0xff, 0xcf, 0x65, 0x2f, 0xee, 0x72, 0x46, 0xf0, 0x13, 0x6, 0x5a, 0x36, 0x16, 0xb0, 0x2d,
0x5c, 0x73, 0xea, 0x42, 0xd6, 0x4b, 0xfc, 0xef, 0x62, 0x1f, 0xd2, 0x9b, 0x88, 0x63, 0xa6, 0xe4,
0x37, 0xc, 0xc5, 0x34, 0x46, 0xae, 0xbf, 0x1e, 0xdb, 0xf5, 0x57, 0x32, 0xae, 0xad, 0xe2, 0x47,
0xe4, 0xf3, 0xd1, 0x8, 0xda, 0x31, 0x3d, 0x53, 0x6, 0xd7, 0x25, 0x63, 0xe6, 0x42, 0xe, 0x88,
0x62, 0x31, 0xae, 0xa8, 0x80, 0x4b, 0x47, 0x15, 0xcc, 0xd9, 0x6f, 0xe3, 0x8e, 0x17, 0xa2, 0x4b};

uint8 aBspCrypto_Rsa_4096_SubjectPublicInfo_PubKeyInf[] = {
    0x30, 0x82, 0x2, 0x22, 0x30, 0xd, 0x6, 0x9, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0xd, 0x1, 0x1,
    0x1, 0x5, 0x0, 0x3, 0x82, 0x2, 0xf, 0x0, 0x30, 0x82, 0x2, 0xa, 0x2, 0x82, 0x2, 0x1,
    0x0, 0x9c, 0xe1, 0x4e, 0x46, 0xda, 0x45, 0xad, 0xa7, 0x78, 0x7e, 0x51, 0x9c, 0x4b, 0x68, 0x3,
    0xf, 0x70, 0x3c, 0x8c, 0x7, 0xf7, 0x9d, 0x76, 0xdb, 0x49, 0x41, 0xda, 0xab, 0x39, 0xe8, 0xf0,
    0x3f, 0x74, 0x15, 0x70, 0x37, 0x58, 0x2e, 0x1, 0xe5, 0xc1, 0xde, 0x1a, 0xaf, 0x9, 0xa7, 0xfa,
    0x33, 0xce, 0x7, 0xec, 0x43, 0x63, 0x97, 0x93, 0x5d, 0x74, 0xc1, 0xbf, 0xc6, 0xa1, 0xbb, 0x92,
    0x57, 0x2e, 0x27, 0x9e, 0x91, 0xd4, 0xc0, 0x9c, 0xfc, 0xc1, 0x7b, 0xcd, 0x4, 0x77, 0x64, 0x83,
    0x3f, 0xd0, 0xbf, 0x2f, 0xa3, 0xcb, 0xa7, 0x6b, 0xa4, 0x56, 0x22, 0x73, 0x2b, 0x12, 0x7b, 0x28,
    0x2f, 0x74, 0x97, 0x26, 0xc, 0xda, 0x26, 0x2e, 0x60, 0x91, 0x44, 0x1c, 0x79, 0x7a, 0xc5, 0x81,
    0xea, 0x3a, 0xc, 0xf9, 0x22, 0x5d, 0x85, 0x5a, 0xdb, 0x61, 0x77, 0xbf, 0xad, 0xa9, 0x2, 0xc4,
    0xf1, 0x8e, 0xdc, 0x3b, 0xf5, 0x36, 0x80, 0xfe, 0x7a, 0xe, 0x21, 0x8c, 0x3a, 0xb1, 0x60, 0xe6,
    0xa8, 0x35, 0xfc, 0x31, 0x90, 0x71, 0x49, 0x76, 0xe, 0x6e, 0xf8, 0xd4, 0xf7, 0xfd, 0x54, 0xc9,
    0x78, 0x79, 0x3, 0x90, 0x76, 0x15, 0x20, 0x60, 0xfc, 0xdf, 0x72, 0x45, 0x9a, 0x18, 0x4c, 0x94,
    0x90, 0x98, 0x7b, 0x4f, 0x6b, 0xc6, 0xe5, 0x5e, 0x40, 0x62, 0xc2, 0x35, 0xd1, 0xcc, 0xc4, 0x40,
    0x29, 0x87, 0xf, 0x90, 0x9f, 0xf5, 0xc1, 0xba, 0x35, 0x17, 0x26, 0x11, 0xe7, 0x8c, 0x5a, 0xd2,
    0xb5, 0x9b, 0x6e, 0x32, 0xbf, 0xdd, 0x5, 0xec, 0x98, 0x42, 0xdd, 0xf7, 0xf4, 0x73, 0x9a, 0x71,
    0xb5, 0xa6, 0x73, 0x51, 0xb4, 0x57, 0x70, 0x4e, 0x4d, 0x70, 0xdf, 0x90, 0xbb, 0x32, 0x16, 0x19,
    0xa1, 0xe8, 0x3a, 0x8c, 0x9d, 0x7f, 0xd2, 0x7, 0x69, 0x13, 0x77, 0xb6, 0x6c, 0xd4, 0x95, 0x47,
    0x8a, 0xb7, 0xfa, 0x54, 0xe5, 0xf8, 0xff, 0x39, 0x3d, 0xf1, 0x56, 0x33, 0xb7, 0xb5, 0xd2, 0x39,
    0xe3, 0x5a, 0x97, 0xae, 0xc7, 0x9a, 0x5a, 0x1c, 0xb8, 0xc7, 0x23, 0xba, 0xff, 0x62, 0x72, 0xd8,
    0xa7, 0x3d, 0xcc, 0xb6, 0xbe, 0x9c, 0x88, 0xeb, 0x67, 0xc9, 0x81, 0xb4, 0xde, 0x14, 0x39, 0xb3,
    0xac, 0x58, 0x12, 0x51, 0xe9, 0x5d, 0xa1, 0xa4, 0x7b, 0x47, 0x26, 0xb1, 0x5a, 0x61, 0x20, 0x9d,
    0xf9, 0x5e, 0x9f, 0xe7, 0xd1, 0x36, 0x4f, 0x60, 0xb, 0xc5, 0x73, 0x7b, 0x82, 0xda, 0x75, 0x4a,
    0x7d, 0x88, 0xe4, 0x23, 0x3, 0xa1, 0xeb, 0xa7, 0x23, 0x77, 0x36, 0xcd, 0x1d, 0x42, 0xb6, 0xff,
    0xf, 0xf8, 0x2f, 0xa2, 0x98, 0x77, 0x9c, 0xe0, 0xaf, 0x30, 0x48, 0xe8, 0x14, 0x9e, 0xd5, 0xce,
    0x44, 0xa, 0x2e, 0x93, 0x79, 0x9b, 0xba, 0x56, 0xcb, 0x73, 0x38, 0x26, 0xd9, 0x51, 0x4b, 0xbc,
    0x8a, 0xba, 0x12, 0xea, 0x72, 0xda, 0xd4, 0x4, 0x16, 0xaa, 0x3, 0x43, 0x4e, 0x86, 0xa9, 0xe0,
    0x5e, 0x7f, 0x18, 0xea, 0x4e, 0x6e, 0x6b, 0x48, 0x13, 0x46, 0x6f, 0xfd, 0xd1, 0x31, 0x4b, 0x4d,
    0xa5, 0x80, 0xc9, 0x97, 0x7f, 0x79, 0xba, 0xcd, 0x7a, 0xb2, 0xac, 0x39, 0xbd, 0xa1, 0x76, 0xf6,
    0x95, 0x5a, 0xb3, 0xb1, 0x9c, 0xf5, 0x8d, 0x5a, 0x20, 0x5a, 0xfb, 0x55, 0x27, 0x4d, 0xde, 0x16,
    0x37, 0x95, 0x1f, 0x9, 0xbb, 0x26, 0xd2, 0xab, 0xee, 0xd, 0x8a, 0x53, 0xe, 0xe9, 0x5, 0xb2,
    0xf8, 0x91, 0xa6, 0xfc, 0x86, 0x2d, 0x45, 0x9c, 0x1e, 0xce, 0xd6, 0x72, 0x48, 0xe1, 0x7b, 0x63,
    0xd8, 0x4a, 0x5d, 0xb7, 0xe7, 0x50, 0xc7, 0x9c, 0x8f, 0xad, 0x5d, 0xce, 0xe, 0x85, 0xed, 0x58,
    0x89, 0x41, 0x33, 0x74, 0xa, 0xb8, 0xa4, 0xc5, 0x82, 0x88, 0xba, 0x3a, 0xc1, 0x11, 0x93, 0xee,
    0x7d, 0x2, 0x3, 0x1, 0x0, 0x1
};

Crypto_PrimitiveInfoType tBspCrypto_PrimitiveInfo_RsaSsaPss = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_RSA,
        .secondaryFamily = CRYPTO_ALGOFAM_SHA2_256,
        .keyLength       = 4096,
        .mode            = CRYPTO_ALGOMODE_RSASSA_PSS,
    }
};

Crypto_JobPrimitiveInfoType tBspCrypto_JobPrimitiveInfo_RsaSsaPss = {
    .callbackId                 = 1,
    .primitiveInfo              = &tBspCrypto_PrimitiveInfo_RsaSsaPss,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tBspCrypto_JobForRsaSsaPssVerify = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aBspCrypto_5bytes_PlainText[0],
            .inputLength = sizeof(aBspCrypto_5bytes_PlainText),
            .secondaryInputPtr = &aBspCrypto_RsaSsaPss_4096_Signature[0],
            .secondaryInputLength = sizeof(aBspCrypto_RsaSsaPss_4096_Signature),
            .verifyPtr = &VerifyResult_RsaSsaPss,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tBspCrypto_JobPrimitiveInfo_RsaSsaPss,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 18,    // -1 -----> index of  Crypto_CryptoKeyList_PC
};

void Bsp_CryptoRsaSsaPssSubjectPublicInfoTest(void)
{
    VerifyResult_RsaSsaPss              = CRYPTO_E_VER_NOT_OK;

    if (E_OK == Crypto_KeyElementSet(tBspCrypto_JobForRsaSsaPssVerify.cryptoKeyId,
                                     CRYPTO_KE_SIGNATURE_KEY /*elementid*/,
                                     &aBspCrypto_Rsa_4096_SubjectPublicInfo_PubKeyInf[0],
                                     sizeof(aBspCrypto_Rsa_4096_SubjectPublicInfo_PubKeyInf))
       )
    {
        if (E_OK == Crypto_KeySetValid(tBspCrypto_JobForRsaSsaPssVerify.cryptoKeyId))
        {
            if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tBspCrypto_JobForRsaSsaPssVerify))
            {
                while (CRYPTO_JOBSTATE_ACTIVE == tBspCrypto_JobForRsaSsaPssVerify.jobState);
            }
        }
        else
        {
            ;
        }
    }
}

uint8 aBspCrypto_RsaSsaPkcs1v15_4096_Signature[]={
0xb, 0xba, 0x54, 0xb7, 0xe1, 0xa2, 0x1c, 0x66, 0x38, 0x57, 0xb4, 0x3c, 0xb1, 0xb5, 0x94, 0x6d,
0x1, 0xea, 0x3f, 0xad, 0x6e, 0x8e, 0xf9, 0xdf, 0x3a, 0x7e, 0x7d, 0x7c, 0x1d, 0xa8, 0xe9, 0x63,
0x71, 0x59, 0xfd, 0x97, 0xf1, 0x2b, 0x9a, 0xb, 0xfc, 0xab, 0xbc, 0xfb, 0xce, 0xf7, 0x91, 0x4c,
0xfd, 0xd1, 0x3f, 0x8d, 0xb7, 0x68, 0x1, 0x96, 0xac, 0x9a, 0x88, 0x2, 0x6a, 0xd3, 0xf9, 0x85,
0x5a, 0x45, 0x7c, 0x91, 0x7e, 0x38, 0x94, 0x67, 0x27, 0x10, 0xbc, 0x46, 0xa1, 0x4d, 0xf9, 0x45,
0x56, 0x23, 0x5f, 0x89, 0x63, 0x72, 0x73, 0x84, 0x3b, 0x7c, 0xe6, 0x46, 0x5a, 0x70, 0x71, 0xc7,
0x1, 0xcc, 0x3c, 0x86, 0x91, 0x51, 0xbb, 0xe1, 0xf4, 0x99, 0xb4, 0x9e, 0x4d, 0xe7, 0xf4, 0xda,
0xe, 0xf6, 0x6d, 0x8d, 0x95, 0xda, 0x48, 0x4d, 0x81, 0x37, 0x64, 0xa5, 0x4, 0x17, 0xa1, 0x90,
0xe6, 0x3d, 0x9, 0xac, 0xc8, 0xab, 0xa3, 0xb0, 0xa6, 0xdb, 0x2c, 0x29, 0x8b, 0x32, 0x4b, 0x69,
0x1d, 0x29, 0x3d, 0x67, 0x94, 0xa7, 0xb2, 0xcf, 0x24, 0x23, 0x49, 0x81, 0x9a, 0x28, 0x5e, 0x28,
0x1d, 0xdf, 0xf1, 0x42, 0xe3, 0x2c, 0xeb, 0xc, 0xe7, 0xdb, 0xa9, 0x86, 0x9e, 0xdd, 0x86, 0xb8,
0xb9, 0x95, 0xdb, 0x7b, 0xb5, 0x70, 0x76, 0xb1, 0xe6, 0x9f, 0xf1, 0xb, 0x3d, 0xe, 0x35, 0x61,
0x6d, 0x72, 0x81, 0x6f, 0x53, 0x30, 0xf1, 0xbd, 0xb, 0x9, 0x5d, 0x4c, 0x1f, 0x1a, 0xe2, 0xcd,
0x45, 0x0, 0xbb, 0xa3, 0x47, 0x50, 0x45, 0xfa, 0xf5, 0x30, 0xb2, 0x18, 0xa1, 0xfe, 0x62, 0x73,
0x42, 0x29, 0xb5, 0xe9, 0xcf, 0xa3, 0xb5, 0xeb, 0x5f, 0x12, 0x4, 0x51, 0x84, 0xc0, 0x3d, 0x9d,
0xfe, 0x51, 0x1a, 0x31, 0x49, 0x6, 0x11, 0x81, 0x79, 0x77, 0x7, 0x49, 0x1f, 0xa4, 0x9b, 0x75,
0x13, 0x7f, 0xe1, 0x36, 0xef, 0xd4, 0xcc, 0x49, 0x0, 0x9e, 0x75, 0xd7, 0xa1, 0xc6, 0xf8, 0x32,
0xe3, 0x60, 0xb5, 0x73, 0x0, 0xf6, 0xc5, 0xf, 0x63, 0x4b, 0xf3, 0x74, 0xce, 0xbd, 0xa0, 0x70,
0x12, 0xd6, 0x55, 0x3e, 0x1, 0x17, 0xdc, 0xe4, 0x2c, 0x7c, 0xc3, 0x37, 0xbd, 0x37, 0x65, 0x2c,
0xa7, 0xf3, 0xae, 0x24, 0xbf, 0xed, 0x89, 0xa8, 0x88, 0xa9, 0x87, 0x45, 0x2d, 0x7c, 0xad, 0x4f,
0xa0, 0x66, 0x2e, 0xec, 0x17, 0xc7, 0x3a, 0x56, 0x80, 0x54, 0x4a, 0x4a, 0xbf, 0xdf, 0x5b, 0xec,
0xcb, 0xec, 0x4, 0x61, 0x2d, 0x3, 0x7c, 0x89, 0x26, 0x47, 0x4e, 0x5d, 0x83, 0x9a, 0x1e, 0x68,
0xfb, 0xb7, 0xc5, 0x23, 0x67, 0x8a, 0xe0, 0x84, 0xbd, 0xf9, 0x6d, 0x22, 0x22, 0x63, 0x37, 0xcb,
0xc2, 0xe2, 0xfa, 0xc1, 0x4f, 0xb9, 0xd9, 0xe, 0xd4, 0x85, 0x61, 0xd7, 0x17, 0x18, 0x4d, 0xce,
0x94, 0x6c, 0xa2, 0x40, 0x9d, 0x1f, 0xd6, 0x80, 0x4a, 0xbe, 0xd4, 0x34, 0xe4, 0x6b, 0x79, 0xd5,
0xa6, 0x2d, 0x1, 0xb3, 0xb3, 0x48, 0x20, 0xfa, 0x96, 0x8a, 0x8a, 0x65, 0x1d, 0x17, 0x2f, 0xcf,
0x9a, 0xfe, 0xcf, 0x2a, 0xd0, 0x2e, 0x84, 0xf4, 0xf3, 0x65, 0x3e, 0x8e, 0xe5, 0x21, 0x9f, 0xd3,
0x2e, 0xf1, 0xc2, 0xfd, 0x24, 0xce, 0x73, 0xaf, 0xfe, 0xbe, 0xae, 0x53, 0x4e, 0x8a, 0x3f, 0x26,
0x7b, 0xa7, 0x22, 0xcf, 0xc3, 0xc8, 0xa7, 0x8e, 0x38, 0x25, 0x9c, 0xd1, 0x3e, 0x14, 0x6f, 0x57,
0xcb, 0xd7, 0x50, 0x6, 0x43, 0x44, 0xf0, 0xcc, 0x5d, 0x88, 0x20, 0x3a, 0xe3, 0x57, 0xa4, 0x98,
0xfd, 0x7b, 0xfc, 0xbc, 0xf3, 0x6, 0x83, 0x7, 0xd4, 0xd3, 0x10, 0x15, 0x9e, 0x48, 0x3, 0x96,
0x33, 0x61, 0x41, 0x58, 0x79, 0x6a, 0x5f, 0x7b, 0x68, 0x74, 0xce, 0x41, 0x22, 0xa7, 0xdd, 0x30};

Crypto_PrimitiveInfoType tBspCrypto_PrimitiveInfo_RsaSsaPkcs1v15 = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_RSA,
        .secondaryFamily = CRYPTO_ALGOFAM_SHA2_256,
        .keyLength       = 4096,
        .mode            = CRYPTO_ALGOMODE_RSASSA_PKCS1_v1_5,
    }
};

Crypto_JobPrimitiveInfoType tBspCrypto_JobPrimitiveInfo_RsaSsaPkcs1v15 = {
    .callbackId                 = 1,
    .primitiveInfo              = &tBspCrypto_PrimitiveInfo_RsaSsaPkcs1v15,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tBspCrypto_JobForRsaSsaPkcs1v15Verify = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aBspCrypto_5bytes_PlainText[0],
            .inputLength = sizeof(aBspCrypto_5bytes_PlainText),
            .secondaryInputPtr = &aBspCrypto_RsaSsaPkcs1v15_4096_Signature[0],
            .secondaryInputLength = sizeof(aBspCrypto_RsaSsaPkcs1v15_4096_Signature),
            .verifyPtr = &RsaPkcs1VerifyResult,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tBspCrypto_JobPrimitiveInfo_RsaSsaPkcs1v15,
    .jobPriority                             = 0,
    .cryptoKeyId                         = 18,    // -1 -----> index of  Crypto_CryptoKeyList_PC
};

void Bsp_CryptoRsaSsaPkcs1v15SubjectPublicInfoTest(void)
{
    RsaPkcs1VerifyResult              = CRYPTO_E_VER_NOT_OK;

    if (E_OK == Crypto_KeyElementSet(tBspCrypto_JobForRsaSsaPkcs1v15Verify.cryptoKeyId,
                                     CRYPTO_KE_SIGNATURE_KEY /*elementid*/,
                                     &aBspCrypto_Rsa_4096_SubjectPublicInfo_PubKeyInf[0],
                                     sizeof(aBspCrypto_Rsa_4096_SubjectPublicInfo_PubKeyInf))
       )
    {
        if (E_OK == Crypto_KeySetValid(tBspCrypto_JobForRsaSsaPkcs1v15Verify.cryptoKeyId))
        {
            if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tBspCrypto_JobForRsaSsaPkcs1v15Verify))
            {
                while (CRYPTO_JOBSTATE_ACTIVE == tBspCrypto_JobForRsaSsaPkcs1v15Verify.jobState);
            }
        }
        else
        {
            ;
        }
    }
}

// private key a4582275b06d60b915931a1048f018ed6e232c57bf5f969b2092bb0230639aa9
uint8 aSm2_PublicKeyXY[64]={
        0x2c, 0xea, 0x78, 0xcf, 0x54, 0x44, 0xe2, 0xfe, 0xd2, 0xdd, 0xaa, 0x58, 0x27, 0xf7, 0xac, 0xf9,
        0xfc, 0x48, 0x18, 0xa7, 0x63, 0x22, 0xa7, 0x2d, 0xaa, 0x7f, 0xf1, 0x19, 0xab, 0x14, 0x0, 0x70,
        0x9, 0x2c, 0xe1, 0x4d, 0x5d, 0x57, 0xe8, 0xf5, 0xaf, 0x82, 0x34, 0x33, 0x6d, 0x9e, 0x97, 0x41,
        0xc7, 0xa6, 0xb0, 0x36, 0x21, 0x9a, 0xa0, 0x7f, 0xd2, 0x15, 0xec, 0x5f, 0x98, 0x80, 0x96, 0x7c,
};
uint8 aSm2_SignatureRS[64]={
        0x94, 0x55, 0xbc, 0x7d, 0xd0, 0x8b, 0xd3, 0xf6, 0x25, 0x2, 0x46, 0x37, 0x5, 0x9a, 0x5f, 0x59,
        0x3c, 0xd, 0x6f, 0x46, 0x25, 0xfd, 0xe2, 0x5d, 0x39, 0x16, 0x27, 0x10, 0x2c, 0x7a, 0xe7, 0x29,
        0xc7, 0x24, 0x56, 0x5, 0x22, 0xad, 0x2b, 0x58, 0xdd, 0xcc, 0x91, 0xdb, 0xb0, 0xca, 0x47, 0x3e,
        0x8e, 0xc8, 0xc3, 0xe6, 0xc1, 0xec, 0xd8, 0xf6, 0x8f, 0x96, 0x66, 0xb1, 0x9b, 0xf2, 0xeb, 0x37,
};
uint8 aSm2_CurveOID[8]={0x2A, 0x81, 0x1C, 0xcf, 0x55, 0x01, 0x82, 0x2d};
uint8 aSm2_Raw_Messege[4]={0x12, 0x34, 0x56, 0x78};

Crypto_VerifyResultType VerifyResult_Sm2 = CRYPTO_E_VER_NOT_OK;

Crypto_PrimitiveInfoType tCryptoPrimitiveInfo_SM2 = {
    .resultLength              = 0,
    .service                   = CRYPTO_SIGNATUREVERIFY,
    .algorithm= {
        .family          = CRYPTO_ALGOFAM_SM2,
        .secondaryFamily = CRYPTO_ALGOFAM_SM3,
        .keyLength       = 256,
        .mode            = CRYPTO_ALGOMODE_NOT_SET,
    }
};

Crypto_JobPrimitiveInfoType tCryptoJobPrimitiveInfo_SM2 = {
    .callbackId                 = 1,
    .primitiveInfo              = &tCryptoPrimitiveInfo_SM2,
    .secureCounterId            = 1,
    .cryIfKeyId                 = 1,
    .processingType             = CRYPTO_PROCESSING_ASYNC,
    .callbackUpdateNotification = TRUE,
};

volatile Crypto_JobType tCryptoJob_SM2 = {
    .jobId    = 1,                       // fisrt job
    .jobState = CRYPTO_JOBSTATE_IDLE,    // active in Crypto_ScheduleJob
    .jobPrimitiveInputOutput = {
            .inputPtr = &aSm2_Raw_Messege[0],
            .inputLength = 4,
            .secondaryInputPtr = &aSm2_SignatureRS[0],
            .secondaryInputLength = 64,
            .verifyPtr = &VerifyResult_Sm2,
            .mode = CRYPTO_OPERATIONMODE_SINGLECALL
    },
    .jobPrimitiveInfo                    = &tCryptoJobPrimitiveInfo_SM2,
    .jobPriority                         = 0,
    .cryptoKeyId                         = 56,    // -4 -----> index of  Crypto_CryptoKeyList_PC
};
void Bsp_CryptoSm2VerifyTest(void)
{
    if (E_OK == Crypto_KeyElementSet(tCryptoJob_SM2.cryptoKeyId,
                                     CRYPTO_KE_SIGNATURE_KEY /*elementid*/,
                                     &aSm2_PublicKeyXY[0],
                                     64)
       )
    {
        if (E_OK == Crypto_KeyElementSet(tCryptoJob_SM2.cryptoKeyId,
                                         CRYPTO_KE_SIGNATURE_CURVETYPE /*elementid*/,
                                         &aSm2_CurveOID[0],
                                         8)
            )
        {
            if (E_OK == Crypto_KeySetValid(tCryptoJob_SM2.cryptoKeyId))
            {
                if (E_OK == Crypto_ProcessJob(1, (Crypto_JobType *)&tCryptoJob_SM2))
                {
                    while (CRYPTO_JOBSTATE_ACTIVE == tCryptoJob_SM2.jobState);
                }
            }
            else
            {
                ;
            }
        }
    }
}
