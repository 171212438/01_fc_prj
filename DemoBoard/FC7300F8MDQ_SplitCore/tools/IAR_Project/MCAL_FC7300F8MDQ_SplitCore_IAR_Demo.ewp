# IAR project MCAL_FC7300F8MDQ_SplitCore_IAR_Demo.ewp, settings and files
configuration FC7300_8M_SplitCore_Debug (ARM, debug)
  General.OGChipSelectEditMenu: FC7300F8MDQxXxxxT1B Flagchip FC7300F8MDQxXxxxT1B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: AUTOSAR_OS_NOT_USED; USE_SW_VECTOR_MODE; __TARGET_USE_FPU; UART_PRINTF
  ICCARM.CCIncludePath2: ../../Include; ../../App/include; ../../_MCAL_multicore_generate_8M/include; ../../_BSW_generate/NvM/include; ../../_BSW_generate/Config; ../../_Compile_Related_Files/Systick/include; ../../_Compile_Related_Files/Det/include; ../../../../MCAL/Src/Adc/include; ../../../../MCAL/Src/Base/include; ../../../../MCAL/Src/Base/include/MemMap; ../../../../MCAL/Src/Can/include; ../../../../MCAL/Src/Common/include; ../../../../MCAL/Src/Crc/include; ../../../../MCAL/Src/Cryif/include; ../../../../MCAL/Src/Crypto/include; ../../../../MCAL/Src/Dem/include; ../../../../MCAL/Src/Dio/include; ../../../../MCAL/Src/DMA/include; ../../../../MCAL/Src/EcuM/include; ../../../../MCAL/Src/Eftu/include; ../../../../MCAL/Src/Eth/include; ../../../../MCAL/Src/EthIf/include; ../../../../MCAL/Src/EthTrcv/include; ../../../../MCAL/Src/Fee/include; ../../../../MCAL/Src/Fls/include; ../../../../MCAL/Src/Gpt/include; ../../../../MCAL/Src/I2c/include; ../../../../MCAL/Src/Icu/include; ../../../../MCAL/Src/Lin/include; ../../../../MCAL/Src/LinIf; ../../../../MCAL/Src/Mb/include; ../../../../MCAL/Src/Mcu/include; ../../../../MCAL/Src/Msc/include; ../../../../MCAL/Src/Ocu/include; ../../../../MCAL/Src/Os/include; ../../../../MCAL/Src/Pfls/include; ../../../../MCAL/Src/Port/include; ../../../../MCAL/Src/Pwm/include; ../../../../MCAL/Src/Qdt/include; ../../../../MCAL/Src/SchM/include; ../../../../MCAL/Src/Sdadc/include; ../../../../MCAL/Src/Sent/include; ../../../../MCAL/Src/Spi/include; ../../../../MCAL/Src/Ssi/include; ../../../../MCAL/Src/TrgSel/include; ../../../../MCAL/Src/Wdg/include; ../../../../MCAL/Src/WdgIf/include; ../../../../MCAL/Src/Uart/include; ../../MiddleWare/RTT; ../../MiddleWare/UartDriver; ../../MiddleWare/Mpu; ..\..\..\..\MCAL\Src\EthSwt\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MCAL_FC7300F8MDQ_SplitCore_IAR_Demo.hex
  ILINK.IlinkOutputFile: MCAL_FC7300F8MDQ_SplitCore_IAR_Demo.out
  ILINK.IlinkIcfFile: Startup\fc7300_8M_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler_Core0
  group _BSW_generate/Config
    ../../_BSW_generate/Config/: CanIf.h CanIf_Cbk.h CanIf_Cfg.h CanIf_Lcfg.h CanIf_Types.h CanIf_Version.h ComStack_Types_Cfg.h MemIf_Types.h MemIf_Version.h Rte_Dem_Type.h Rte_Type.h
  group _BSW_generate/NvM/include
    ../../_BSW_generate/NvM/include/: NvM_Cbk.h
  group _BSW_generate/NvM/source
    ../../_BSW_generate/NvM/source/: NvM_Cbk.c
  group _Compile_Related_Files/Det/include
    ../../_Compile_Related_Files/Det/include/: Det.h
  group _Compile_Related_Files/Det/src
    ../../_Compile_Related_Files/Det/src/: Det.c
  group _Compile_Related_Files/Systick/include
    ../../_Compile_Related_Files/Systick/include/: Systick.h Systick_Cfg.h Systick_Hw.h Systick_Reg.h Systick_Type.h
  group _Compile_Related_Files/Systick/src
    ../../_Compile_Related_Files/Systick/src/: Systick.c Systick_Hw.c Systick_Irq.c Systick_PBCfg.c
  group _MCAL_multicore_generate_8M/include
    ../../_MCAL_multicore_generate_8M/include/: Adc_Cfg.h Adc_CfgDefines.h Can_Cfg.h Can_MainFunction.h Can_PBcfg.h CDD_DMA_Cfg.h CDD_Eftu_Cfg.h CDD_I2c_Cfg.h CDD_Mb_Cfg.h CDD_Msc_Cfg.h CDD_Msc_PBCfg.h CDD_QDT_Cfg.h CDD_Sdadc_Cfg.h CDD_Sdadc_PBCfg.h CDD_SENT_Cfg.h CDD_Ssi_Cfg.h CDD_TrgSel_Cfg.h CDD_Uart_Cfg.h CDD_Uart_Defines.h CDD_Uart_PBcfg.h Common_Cfg.h Crc_Cfg.h CryIf_Cfg.h Crypto_Cfg.h Dem_IntErrId.h Dio_Cfg.h EcuC_Cfg.h EcuM_Cfg.h Eth_Cfg.h Eth_CfgDefines.h Eth_PBcfg.h EthTrcv_Cfg.h EthTrcv_CfgDefines.h Fee_Cfg.h Fls_Cfg.h Gpt_Cfg.h Icu_Cfg.h Lin_Cfg.h Mcu_Cfg.h Mcu_CfgPlatformDef.h Ocu_Cfg.h Os_Cfg.h Os_PBcfg.h Pfls_Cfg.h Port_Cfg.h Pwm_Cfg.h Pwm_PBcfg.h Spi_Cfg.h Wdg_Cfg.h
  group _MCAL_multicore_generate_8M/src
    ../../_MCAL_multicore_generate_8M/src/: Adc_Cfg.c Adc_PBcfg.c Can_Irq.c Can_MainFunction.c Can_PBcfg.c CDD_DMA_Cfg.c CDD_Eftu_Cfg.c CDD_Eftu_PBcfg.c CDD_I2c_Cfg.c CDD_I2c_PBcfg.c CDD_Mb_Cfg.c CDD_Mb_PBcfg.c CDD_Msc_Cfg.c CDD_Msc_PBCfg.c CDD_QDT_Cfg.c CDD_Sdadc_PBCfg.c CDD_SENT_Cfg.c CDD_Ssi_Cfg.c CDD_TrgSel_Cfg.c CDD_TrgSel_PBcfg.c CDD_Uart_PBcfg.c Crc_Cfg.c CryIf_Cfg.c Crypto_Cfg.c Dio_Cfg.c Eth_PBcfg.c EthTrcv_PBcfg.c Fee_Cfg.c Fls_Cfg.c Fls_PBcfg.c Gpt_Cfg.c Gpt_PBcfg.c Icu_Cfg.c Icu_DmaNotification.c Icu_PBcfg.c Lin_Cfg.c Lin_PBcfg.c Mcu_Cfg.c Mcu_PBcfg.c Ocu_PBcfg.c Os_PBcfg.c Pfls_Cfg.c Pfls_PBcfg.c Port_Cfg.c Port_PBcfg.c Pwm_PBcfg.c Spi_Cfg.c Spi_PBcfg.c Wdg_174_Instance0_PBcfg.c Wdg_174_Instance1_PBcfg.c Wdg_174_Instance2_PBcfg.c Wdg_174_Instance3_PBcfg.c Wdg_Cfg.c
  group App/Include
    ../../App/Include/: Bsp_Adc.h Bsp_Can.h Bsp_Crc.h Bsp_Crypto.h Bsp_Dma.h Bsp_Eth.h Bsp_EthIf.h Bsp_EthSM.h Bsp_EthTrcv.h Bsp_Fee.h Bsp_Fls.h Bsp_Gpt.h Bsp_I2c.h Bsp_Icu.h Bsp_InterruptManager.h Bsp_io.h Bsp_Lin.h Bsp_Mb.h Bsp_McalHeader.h Bsp_Mcu.h Bsp_MemMap.h Bsp_Msc.h Bsp_Ocu.h Bsp_Pwm.h Bsp_Qdt.h Bsp_Sdadc.h Bsp_Sent.h Bsp_Spi.h Bsp_Ssi.h Bsp_Trgsel.h Bsp_Uart.h Bsp_Wdg.h
  group App/Source
    ../../App/Source/: Bsp_Adc.c Bsp_Can.c Bsp_Crc.c Bsp_Crypto.c Bsp_Dma.c Bsp_Eth.c Bsp_EthIf.c Bsp_EthSM.c Bsp_EthTrcv.c Bsp_Fee.c Bsp_Fls.c Bsp_Gpt.c Bsp_I2c.c Bsp_Icu.c Bsp_InterruptManager.c Bsp_io.c Bsp_Lin.c Bsp_Mb.c Bsp_Mcu.c Bsp_Msc.c Bsp_Ocu.c Bsp_Pwm.c Bsp_Qdt.c Bsp_Sdadc.c Bsp_Sent.c Bsp_Spi.c Bsp_Ssi.c Bsp_Trgsel.c Bsp_Uart.c Bsp_Wdg.c
  group MCAL/Src/Adc/include
    ../../../../MCAL/Src/Adc/include/: Adc.h Adc_Hal.h Adc_HsAdc.h Adc_HsAdc_Reg.h Adc_HsAdc_RegOps.h Adc_HsAdc_Types.h Adc_Ipw.h Adc_Ptimer.h Adc_Ptimer_Reg.h Adc_Ptimer_RegOps.h Adc_Ptimer_Types.h Adc_SarAdc.h Adc_SarAdc_Reg.h Adc_SarAdc_RegOps.h Adc_SarAdc_Types.h Adc_Tmu.h Adc_Tmu_Reg.h Adc_Tmu_RegOps.h Adc_Types.h Adc_Version.h
  group MCAL/Src/Adc/src
    ../../../../MCAL/Src/Adc/src/: Adc.c Adc_Hal.c Adc_HsAdc.c Adc_HsAdc_Irq.c Adc_Ipw.c Adc_Ptimer.c Adc_Ptimer_Irq.c Adc_SarAdc.c Adc_SarAdc_Irq.c Adc_Tmu.c Adc_Tmu_Irq.c
  group MCAL/Src/Base/include
    ../../../../MCAL/Src/Base/include/: Compiler.h Compiler_Cfg.h CompilerDefinition.h ComStack_Types.h Eth_GeneralTypes.h Mcal.h Platform_Types.h Std_Types.h
  group MCAL/Src/Base/include/MemMap
    ../../../../MCAL/Src/Base/include/MemMap/: Adc_MemMap.h Can_MemMap.h Common_MemMap.h Crc_MemMap.h Crypto_MemMap.h Dem_MemMap.h Dio_MemMap.h Dma_MemMap.h Eftu_MemMap.h Eth_MemMap.h EthTrcv_MemMap.h Fee_MemMap.h Fls_MemMap.h Gpt_MemMap.h I2c_MemMap.h Icu_MemMap.h Lin_MemMap.h Mb_MemMap.h Mcu_MemMap.h Msc_MemMap.h Ocu_MemMap.h Ospi_MemMap.h Port_MemMap.h Pwm_MemMap.h Rte_MemMap.h Sdadc_MemMap.h Sent_MemMap.h Spi_MemMap.h TrgSel_MemMap.h Uart_MemMap.h Wdg_MemMap.h
  group MCAL/Src/Can/include
    ../../../../MCAL/Src/Can/include/: Can.h Can_ControllerType.h Can_GeneralTypes.h Can_GeneralTypes_Cfg.h Can_Hal.h Can_Hw.h Can_HwType.h Can_Reg.h Can_Version.h
  group MCAL/Src/Can/src
    ../../../../MCAL/Src/Can/src/: Can.c Can_Hal.c Can_Hw.c
  group MCAL/Src/Common/include
    ../../../../MCAL/Src/Common/include/: Aontimer_Reg.h Cpm_Reg.h Eftu_Common_Types.h Eftu_Dtm_Reg.h Eftu_Tom_Reg.h Fcpit_Reg.h Ftu_Common.h Ftu_Reg.h Ftu_RegOps.h Gpio_Reg.h IRQRouter.h Mb_Reg.h Mb_RegOps.h Port_Reg.h Scm_Reg.h Scm_RegOps.h Sema_Reg.h Sema_RegOps.h SpinLock.h StdRegMacros.h Tpu_E_Reg.h Tpu_H_Reg.h Tstmp_Reg.h Uart_Reg.h
  group MCAL/Src/Common/src
    ../../../../MCAL/Src/Common/src/: Aontimer_Common.c Ftu_Common.c IRQRouter.c Port_Common.c Tpu_Common.c
  group MCAL/Src/Crc/include
    ../../../../MCAL/Src/Crc/include/: Crc.h Crc_Hw.h Crc_Lookup_Tables.h Crc_Reg.h Crc_RegOps.h Crc_Reverse.h Crc_RunTime.h Crc_Types.h Crc_Version.h
  group MCAL/Src/Crc/src
    ../../../../MCAL/Src/Crc/src/: Crc.c Crc_Hw.c Crc_Lookup_Tables.c Crc_Reverse.c Crc_RunTime.c
  group MCAL/Src/CryIf/include
    ../../../../MCAL/Src/CryIf/include/: CryIf.h CryIf_Version.h
  group MCAL/Src/CryIf/src
    ../../../../MCAL/Src/CryIf/src/: CryIf.c
  group MCAL/Src/Crypto/include
    ../../../../MCAL/Src/Crypto/include/: Crypto.h Crypto_Hsm.h Crypto_KeyManagement.h Crypto_Level0Api.h Crypto_Level1Api.h Crypto_Level2Api.h Crypto_Level3Api.h Crypto_LevelNApi.h Crypto_LLD.h Crypto_Version.h Csm_Cbk.h Csm_Types.h
  group MCAL/Src/Crypto/src
    ../../../../MCAL/Src/Crypto/src/: Crypto.c Crypto_Hsm.c Crypto_KeyManagement.c Crypto_Level0Api.c Crypto_Level1Api.c Crypto_Level2Api.c Crypto_Level3Api.c Crypto_LevelNApi.c Crypto_LLD.c Csm.c
  group MCAL/Src/Dem/include
    ../../../../MCAL/Src/Dem/include/: Dem.h Dem_Types.h Dem_version.h
  group MCAL/Src/Dem/src
    ../../../../MCAL/Src/Dem/src/: Dem.c
  group MCAL/Src/Dio/include
    ../../../../MCAL/Src/Dio/include/: Dio.h Dio_Hw.h Dio_Hw_Types.h Dio_Reg.h Dio_RegOps.h Dio_version.h
  group MCAL/Src/Dio/src
    ../../../../MCAL/Src/Dio/src/: Dio.c Dio_Hw.c
  group MCAL/Src/Dma/include
    ../../../../MCAL/Src/Dma/include/: CDD_Dma.h Dma_HWA.h Dma_LLD.h Dma_Types.h DmaMux_HWA.h DmaMux_Reg.h FC7240_Dma_Reg.h FC7300_Dma_Reg.h FC7300GT_Dma_Reg.h
  group MCAL/Src/Dma/src
    ../../../../MCAL/Src/Dma/src/: CDD_Dma.c Dma_Isr.c Dma_LLD.c
  group MCAL/Src/EcuM/include
    ../../../../MCAL/Src/EcuM/include/: EcuM.h EcuM_Cbk.h EcuM_version.h
  group MCAL/Src/EcuM/src
    ../../../../MCAL/Src/EcuM/src/: EcuM.c
  group MCAL/Src/Eftu/include
    ../../../../MCAL/Src/Eftu/include/: CDD_Eftu.h CDD_Eftu_Hw.h CDD_Eftu_Types.h CDD_Eftu_Version.h Eftu_Ccm.h Eftu_Ccm_Reg.h Eftu_Ccm_Types.h Eftu_Cmu.h Eftu_Cmu_Reg.h Eftu_Cmu_Types.h Eftu_Tbu.h Eftu_Tbu_Reg.h Eftu_Tbu_Types.h Eftu_Tom.h Eftu_Tom_Types.h
  group MCAL/Src/Eftu/src
    ../../../../MCAL/Src/Eftu/src/: CDD_Eftu.c CDD_Eftu_Hw.c Eftu_Ccm.c Eftu_Cmu.c Eftu_Tbu.c Eftu_Tom.c
  group MCAL/Src/Eth/include
    ../../../../MCAL/Src/Eth/include/: Eth.h Eth_Hal.h Eth_Hw.h Eth_Hw_Types.h Eth_Reg.h Eth_Types.h Eth_Version.h
  group MCAL/Src/Eth/src
    ../../../../MCAL/Src/Eth/src/: Eth.c Eth_Hal.c Eth_Irq.c
  group MCAL/Src/EthSwt/include
    ../../../../MCAL/Src/EthSwt/include/: EthSwt.h
  group MCAL/Src/EthSwt/src
    ../../../../MCAL/Src/EthSwt/src/: EthSwt.c
  group MCAL/Src/EthTrcv/include
    ../../../../MCAL/Src/EthTrcv/include/: EthTrcv.h EthTrcv_Hal.h EthTrcv_Hw.h EthTrcv_Reg.h EthTrcv_Types.h EthTrcv_Version.h
  group MCAL/Src/EthTrcv/src
    ../../../../MCAL/Src/EthTrcv/src/: EthTrcv.c EthTrcv_Hal.c EthTrcv_Hw.c
  group MCAL/Src/Fee/include
    ../../../../MCAL/Src/Fee/include/: Fee.h Fee_Cbk.h Fee_ChunkSwitch.h Fee_Extra.h Fee_Initialization.h Fee_Internal.h Fee_InternalTypes.h Fee_Reserve.h Fee_RestoreJob.h Fee_Types.h Fee_Version.h
  group MCAL/Src/Fee/src
    ../../../../MCAL/Src/Fee/src/: Fee.c Fee_ChunkSwitch.c Fee_Extra.c Fee_Initialization.c Fee_Internal.c Fee_Reserve.c Fee_RestoreJob.c
  group MCAL/Src/Fls/include
    ../../../../MCAL/Src/Fls/include/: Fcfmc_RegOps.h Fcfmc_Regs.h Fls.h Fls_Driver.h Fls_Flash.h Fls_Flash_Types.h Fls_Hal.h Fls_Types.h Fls_version.h
  group MCAL/Src/Fls/src
    ../../../../MCAL/Src/Fls/src/: Fls.c Fls_Flash.c Fls_Hal.c
  group MCAL/Src/Gpt/include
    ../../../../MCAL/Src/Gpt/include/: Gpt.h Gpt_Aontimer.h Gpt_Aontimer_RegOps.h Gpt_Aontimer_Types.h Gpt_EftuTom.h Gpt_EftuTom_RegOps.h Gpt_EftuTom_Types.h Gpt_Fcpit.h Gpt_Fcpit_RegOps.h Gpt_Fcpit_Types.h Gpt_Ftu.h Gpt_Ftu_RegOps.h Gpt_Ftu_Types.h Gpt_Hw.h Gpt_Hw_Irq.h Gpt_Hw_Types.h Gpt_Irq.h Gpt_Ptimer.h Gpt_Ptimer_Reg.h Gpt_Ptimer_RegOps.h Gpt_Ptimer_Types.h Gpt_Rtc.h Gpt_Rtc_Reg.h Gpt_Rtc_RegOps.h Gpt_Rtc_Types.h Gpt_Tpu.h Gpt_Tpu_RegOps.h Gpt_Tpu_Types.h Gpt_Tstmp.h Gpt_Tstmp_RegOps.h Gpt_Tstmp_Types.h Gpt_version.h
  group MCAL/Src/Gpt/src
    ../../../../MCAL/Src/Gpt/src/: Gpt.c Gpt_Aontimer.c Gpt_EftuTom.c Gpt_Fcpit.c Gpt_Ftu.c Gpt_Hw.c Gpt_Ptimer.c Gpt_Rtc.c Gpt_Tpu.c Gpt_Tstmp.c
  group MCAL/Src/I2c/include
    ../../../../MCAL/Src/I2c/include/: CDD_I2c.h CDD_I2c_Hw.h CDD_I2c_HwType.h CDD_I2c_Reg.h CDD_I2c_RegOps.h CDD_I2c_Types.h I2c_version.h
  group MCAL/Src/I2c/src
    ../../../../MCAL/Src/I2c/src/: CDD_I2c.c CDD_I2c_Hw.c CDD_I2c_Irq.c
  group MCAL/Src/Icu/include
    ../../../../MCAL/Src/Icu/include/: Icu.h Icu_Aontimer.h Icu_Aontimer_Types.h Icu_Cmp.h Icu_Cmp_Reg.h Icu_Cmp_Types.h Icu_Eftu_Tim.h Icu_Eftu_Tim_Reg.h Icu_Eftu_Tim_RegOps.h Icu_Eftu_Tim_Types.h Icu_Fcpit.h Icu_Fcpit_RegOps.h Icu_Fcpit_Types.h Icu_Ftu.h Icu_Ftu_Types.h Icu_Hw.h Icu_Hw_Types.h Icu_Ism.h Icu_Ism_Reg.h Icu_Ism_Types.h Icu_MemMap.h Icu_Port.h Icu_Port_Types.h Icu_Tpu.h Icu_Tpu_Types.h Icu_Types.h Icu_Version.h
  group MCAL/Src/Icu/src
    ../../../../MCAL/Src/Icu/src/: Icu.c Icu_Aontimer.c Icu_Cmp.c Icu_Eftu_Tim.c Icu_Fcpit.c Icu_Ftu.c Icu_Hw.c Icu_Ism.c Icu_Port.c Icu_Tpu.c
  group MCAL/Src/Lin/include
    ../../../../MCAL/Src/Lin/include/: Lin.h Lin_FCUart.h Lin_FCUart_RegOps.h Lin_GeneralTypes.h Lin_version.h
  group MCAL/Src/Lin/src
    ../../../../MCAL/Src/Lin/src/: Lin.c Lin_FCUart.c Lin_Irq.c
  group MCAL/Src/LinIf
    ../../../../MCAL/Src/LinIf/: LinIf.c LinIf.h LinIf_Cbk.h
  group MCAL/Src/Mb/include
    ../../../../MCAL/Src/Mb/include/: CDD_Mb.h CDD_Mb_Hw.h CDD_Mb_Hw_Types.h CDD_Mb_Types.h CDD_Mb_Version.h
  group MCAL/Src/Mb/src
    ../../../../MCAL/Src/Mb/src/: CDD_Mb.c CDD_Mb_Hw.c CDD_Mb_Irq.c
  group MCAL/Src/Mcu/include
    ../../../../MCAL/Src/Mcu/include/: Mcu.h Mcu_CM7_RegOps.h Mcu_CM7_Regs.h Mcu_Cmu.h Mcu_Cmu_RegOps.h Mcu_Cmu_Regs.h Mcu_Csc.h Mcu_Csc_RegOps.h Mcu_Csc_Regs.h Mcu_Hw.h Mcu_Hw_Types.h Mcu_Pcc.h Mcu_Pmc.h Mcu_Pmc_RegOps.h Mcu_Pmc_Regs.h Mcu_Rgm.h Mcu_Rgm_RegOps.h Mcu_Rgm_Regs.h Mcu_Scg.h Mcu_Scg_RegOps.h Mcu_Scg_Regs.h Mcu_Scm.h Mcu_Scm_RegOps.h Mcu_Smc.h Mcu_Smc_RegOps.h Mcu_Smc_Regs.h Mcu_Version.h Mcu_Wku.h Mcu_Wku_RegOps.h Mcu_Wku_Regs.h
  group MCAL/Src/Mcu/src
    ../../../../MCAL/Src/Mcu/src/: Mcu.c Mcu_Cmu.c Mcu_Csc.c Mcu_Hw.c Mcu_Irq.c Mcu_Pcc.c Mcu_Pmc.c Mcu_Rgm.c Mcu_Scg.c Mcu_Scm.c Mcu_Smc.c Mcu_Wku.c
  group MCAL/Src/Msc/include
    ../../../../MCAL/Src/Msc/include/: CDD_Msc.h CDD_Msc_Hw.h CDD_Msc_LLD.h CDD_Msc_Reg.h CDD_Msc_version.h
  group MCAL/Src/Msc/src
    ../../../../MCAL/Src/Msc/src/: CDD_Msc.c CDD_Msc_Irq.c CDD_Msc_LLD.c
  group MCAL/Src/Ocu/include
    ../../../../MCAL/Src/Ocu/include/: Ocu.h Ocu_Eftu_Tom.h Ocu_Eftu_Tom_RegOps.h Ocu_Eftu_Tom_Types.h Ocu_Ftu.h Ocu_Ftu_RegOps.h Ocu_Ftu_Types.h Ocu_Hw.h Ocu_Hw_Irq.h Ocu_Hw_Types.h Ocu_Irq.h Ocu_Tpu.h Ocu_Tpu_E_RegOps.h Ocu_Tpu_Types.h Ocu_Types.h Ocu_Version.h
  group MCAL/Src/Ocu/src
    ../../../../MCAL/Src/Ocu/src/: Ocu.c Ocu_Eftu_Tom.c Ocu_Ftu.c Ocu_Hw.c Ocu_Tpu.c
  group MCAL/Src/Os/include
    ../../../../MCAL/Src/Os/include/: Os.h
  group MCAL/Src/Os/src
    ../../../../MCAL/Src/Os/src/: Os.c
  group MCAL/Src/Pfls/include
    ../../../../MCAL/Src/Pfls/include/: Pfcfmc_RegOps.h Pfcfmc_Regs.h Pfls.h Pfls_Driver.h Pfls_Flash.h Pfls_Flash_Types.h Pfls_Hal.h Pfls_Types.h Pfls_version.h
  group MCAL/Src/Pfls/src
    ../../../../MCAL/Src/Pfls/src/: Pfls.c Pfls_Flash.c Pfls_Hal.c
  group MCAL/Src/Port/include
    ../../../../MCAL/Src/Port/include/: Gpio_RegOps.h Port.h Port_Hw.h Port_Hw_Types.h Port_RegOps.h Port_version.h
  group MCAL/Src/Port/src
    ../../../../MCAL/Src/Port/src/: Port.c Port_Hw.c
  group MCAL/Src/Pwm/include
    ../../../../MCAL/Src/Pwm/include/: Pwm.h Pwm_Eftu_Dtm_RegOps.h Pwm_Eftu_Tom.h Pwm_Eftu_Tom_RegOps.h Pwm_Eftu_Types.h Pwm_Ftu.h Pwm_Ftu_Types.h Pwm_Hrpwm_Reg.h Pwm_Hrpwm_RegOps.h Pwm_Hw.h Pwm_Hw_Types.h Pwm_Types.h Pwm_version.h
  group MCAL/Src/Pwm/src
    ../../../../MCAL/Src/Pwm/src/: Pwm.c Pwm_Eftu_Tom.c Pwm_Ftu.c Pwm_Hw.c
  group MCAL/Src/Qdt/include
    ../../../../MCAL/Src/Qdt/include/: CDD_Qdt.h Qdt_Hal.h Qdt_HWA.h Qdt_Reg.h
  group MCAL/Src/Qdt/src
    ../../../../MCAL/Src/Qdt/src/: CDD_Qdt.c Qdt_Hal.c Qdt_Isr.c
  group MCAL/Src/SchM/include
    ../../../../MCAL/Src/SchM/include/: SchM_Adc.h SchM_Can.h SchM_Common.h SchM_Crcu.h SchM_Crypto.h SchM_Dio.h SchM_Dma.h SchM_Eep.h SchM_Eth.h SchM_EthTrcv.h SchM_Fee.h SchM_Fls.h SchM_Gpt.h SchM_I2c.h SchM_Icu.h SchM_Lin.h SchM_Mb.h SchM_Mcu.h SchM_Msc.h SchM_Ocu.h SchM_Ospi.h SchM_Pfls.h SchM_Port.h SchM_Pwm.h SchM_Qdt.h SchM_Sdadc.h SchM_Sent.h SchM_Spi.h SchM_Ssi.h SchM_Uart.h SchM_Wdg.h
  group MCAL/Src/SchM/src
    ../../../../MCAL/Src/SchM/src/: SchM_Adc.c SchM_Can.c SchM_Common.c SchM_Crcu.c SchM_Crypto.c SchM_Dio.c SchM_Dma.c SchM_Eep.c SchM_Eth.c SchM_EthTrcv.c SchM_Fee.c SchM_Fls.c SchM_Gpt.c SchM_I2c.c SchM_Icu.c SchM_Lin.c SchM_Mb.c SchM_Mcu.c SchM_Msc.c SchM_Ocu.c SchM_Ospi.c SchM_Pfls.c SchM_Port.c SchM_Pwm.c SchM_Qdt.c SchM_Sdadc.c SchM_Sent.c SchM_Spi.c SchM_Ssi.c SchM_Uart.c SchM_Wdg.c
  group MCAL/Src/Sdadc/include
    ../../../../MCAL/Src/Sdadc/include/: CDD_Sdadc.h CDD_Sdadc_Hw.h CDD_Sdadc_LLD.h CDD_Sdadc_Regs.h CDD_Sdadc_Version.h
  group MCAL/Src/Sdadc/src
    ../../../../MCAL/Src/Sdadc/src/: CDD_Sdadc.c CDD_Sdadc_Irq.c CDD_Sdadc_LLD.c
  group MCAL/Src/Sent/include
    ../../../../MCAL/Src/Sent/include/: CDD_Sent.h Sent_Hal.h Sent_HWA.h Sent_Reg.h
  group MCAL/Src/Sent/src
    ../../../../MCAL/Src/Sent/src/: CDD_Sent.c Sent_Hal.c Sent_Isr.c
  group MCAL/Src/Spi/include
    ../../../../MCAL/Src/Spi/include/: Spi.h Spi_FCSpi.h Spi_RegOps.h Spi_version.h
  group MCAL/Src/Spi/src
    ../../../../MCAL/Src/Spi/src/: Spi.c Spi_FCSpi.c Spi_FCSpi_Irq.c
  group MCAL/Src/Ssi/include
    ../../../../MCAL/Src/Ssi/include/: CDD_Ssi.h Ssi_Hal.h Ssi_HWA.h Ssi_Reg.h
  group MCAL/Src/Ssi/src
    ../../../../MCAL/Src/Ssi/src/: CDD_Ssi.c Ssi_Hal.c Ssi_Isr.c
  group MCAL/Src/TrgSel/include
    ../../../../MCAL/Src/TrgSel/include/: CDD_TrgSel.h TrgSel_Drv.h TrgSel_Reg.h TrgSel_Types.h TrgSel_Version.h
  group MCAL/Src/TrgSel/src
    ../../../../MCAL/Src/TrgSel/src/: CDD_Trgsel.c Trgsel_Drv.c
  group MCAL/Src/Uart/include
    ../../../../MCAL/Src/Uart/include/: CDD_Uart.h LLD_Uart.h Uart_GeneralTypes.h Uart_Irq.h Uart_RegOps.h Uart_Types.h Uart_Version.h
  group MCAL/Src/Uart/src
    ../../../../MCAL/Src/Uart/src/: CDD_Uart.c CDD_Uart_Irq.c LLD_Uart.c
  group MCAL/Src/Wdg/include
    ../../../../MCAL/Src/Wdg/include/: Wdg_174_Instance0.h Wdg_174_Instance0_Cbk.h Wdg_174_Instance1.h Wdg_174_Instance1_Cbk.h Wdg_174_Instance2.h Wdg_174_Instance2_Cbk.h Wdg_174_Instance3.h Wdg_174_Instance3_Cbk.h Wdg_HLD.h Wdg_Irq.h Wdg_LLD.h Wdg_LLD_Types.h Wdg_Reg.h Wdg_RegOps.h Wdg_Version.h
  group MCAL/Src/Wdg/src
    ../../../../MCAL/Src/Wdg/src/: Wdg_174_Instance0.c Wdg_174_Instance1.c Wdg_174_Instance2.c Wdg_174_Instance3.c Wdg_HLD.c Wdg_Irq.c Wdg_LLD.c
  group MCAL/Src/WdgIf/include
    ../../../../MCAL/Src/WdgIf/include/: WdgIf.h WdgIf_Cfg.h WdgIf_Types.h
  group MCAL/Src/WdgIf/src
    ../../../../MCAL/Src/WdgIf/src/: WdgIf.c
  group MiddleWare/Mpu
    ../../MiddleWare/Mpu/: fc7xxx_driver_mpu.c fc7xxx_driver_mpu.h HwA_mpu.h Mpu.c Mpu.h
  group MiddleWare/RTT
    ../../MiddleWare/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group MiddleWare/UartDriver
    ../../MiddleWare/UartDriver/: syscalls.c UART.c UART.h
  group Source
    ../../Source/: interrupt_functions.c interrupt_manager.c main_multicore.c
  group Startup
    Startup/: fc7300_8M_flash.icf startup_core0_iar.s startup_core1_iar.s startup_core2_iar.s startup_core3_iar.s system_init.c
